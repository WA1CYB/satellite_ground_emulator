<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>feedforward_test</value></param>
<param><key>author</key><value>WA1CYB</value></param>
<param><key>comment</key><value>gnd_test_1 is created from sat_test_4

with appropriate deletions and reformatting</value></param>
<param><key>description</key><value>feedforward_test</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>feedforward_test</value></param>
</block>
<block>
<key>variable_low_pass_filter_taps</key>
<param><key>id</key><value>D9600_xlate_filter_taps_0</value></param>
<param><key>cutoff_freq</key><value>9.6e3/2</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>samp_rate</key><value>samp_rate_sr2/16</value></param>
<param><key>width</key><value>100</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>ampl</value></param>
<param><key>value</key><value>0.05</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>label</key><value>Xmit Input Level</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.005</value></param>
<param><key>stop</key><value>.5</value></param>
<param><key>widget</key><value>counter</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>atten_in_dB</value></param>
<param><key>value</key><value>-65</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>2,1,1,1</value></param>
<param><key>label</key><value>"GR1 Input Atten"</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-120</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>0</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>atten_in_dB_gr2</value></param>
<param><key>value</key><value>-10</value></param>
<param><key>gui_hint</key><value>2,2,1,1</value></param>
<param><key>label</key><value>"LNB GR2 Input Atten"</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-120</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>audio_rate</value></param>
<param><key>value</key><value>48000</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>audio_selection</value></param>
<param><key>value</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>6,2,1,1</value></param>
<param><key>label0</key><value>No audio</value></param>
<param><key>label1</key><value>Local HT</value></param>
<param><key>label2</key><value>Sat Rcv </value></param>
<param><key>label3</key><value>USB/CW</value></param>
<param><key>label4</key><value>IP Out</value></param>
<param><key>num_opts</key><value>5</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>option1</key><value>1</value></param>
<param><key>option2</key><value>2</value></param>
<param><key>option3</key><value>3</value></param>
<param><key>option4</key><value>4</value></param>
<param><key>orient</key><value>Qt.QHBoxLayout</value></param>
<param><key>type</key><value>int</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>audio_source</value></param>
<param><key>value</key><value>2</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>3,1,1,1</value></param>
<param><key>label0</key><value>nbfm audio</value></param>
<param><key>label1</key><value>USB Audio</value></param>
<param><key>label2</key><value>All Audio Muted</value></param>
<param><key>label3</key><value>LSB Audio</value></param>
<param><key>label4</key><value>TCP/IP Output</value></param>
<param><key>label</key><value>Audio Source Select</value></param>
<param><key>num_opts</key><value>5</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>option1</key><value>1</value></param>
<param><key>option2</key><value>2</value></param>
<param><key>option3</key><value>3</value></param>
<param><key>option4</key><value>4</value></param>
<param><key>type</key><value>int</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>band_width</value></param>
<param><key>comment</key><value>samp_rate_sr1/4 = 250 kHz

samp_rate_sr1/8 = 125 kHz

chan_width * num_chans = 25*7= 175</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>chan_width * num_chans</value></param>
</block>
<block>
<key>variable_low_pass_filter_taps</key>
<param><key>id</key><value>band_xlate_filter_taps_0</value></param>
<param><key>cutoff_freq</key><value>256e3/4</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>samp_rate</key><value>samp_rate_sr1</value></param>
<param><key>width</key><value>0.1*(128e3)/2</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>variable_band_pass_filter_taps</key>
<param><key>id</key><value>bpf_taps</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>high_cutoff_freq</key><value>2800</value></param>
<param><key>low_cutoff_freq</key><value>200</value></param>
<param><key>samp_rate</key><value>samp_rate_sr2/4</value></param>
<param><key>type</key><value>taps_real</value></param>
<param><key>width</key><value>1000</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>chan_map_out</value></param>
<param><key>comment</key><value>Channel Mapping:

range((num_chans+1)/2, (num_chans))+ [0] + range(1, (1+num_chans)/2)</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>[]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>chan_width</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>int(samp_rate_sr1/8)/16/4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>channel_map</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>[]</value></param>
</block>
<block>
<key>variable_low_pass_filter_taps</key>
<param><key>id</key><value>cw_xlate_filter_taps_0</value></param>
<param><key>cutoff_freq</key><value>.4e3</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>samp_rate</key><value>samp_rate_sr2/16</value></param>
<param><key>width</key><value>100</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>enable_feedback</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>2,3,1,1</value></param>
<param><key>label0</key><value>Un-Lock</value></param>
<param><key>label1</key><value>Lock Frequency</value></param>
<param><key>label</key><value>Enable Feedback</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>option1</key><value>1</value></param>
<param><key>orient</key><value>Qt.QHBoxLayout</value></param>
<param><key>type</key><value>real</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fft_interval</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>(1.0/20)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fftwidth</value></param>
<param><key>comment</key><value>Short FFT is ok
for the narrow
audio signal

Also used to set
the output buffer
size</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>512</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>gr2_atten_linear</value></param>
<param><key>value</key><value>1/(10**(-atten_in_dB_gr2/20.))</value></param>
</block>
<block>
<key>variable_low_pass_filter_taps</key>
<param><key>id</key><value>half_band_xlate_filter_taps_0</value></param>
<param><key>cutoff_freq</key><value>64e3/2</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>samp_rate</key><value>samp_rate_sr1/2</value></param>
<param><key>width</key><value>5e3</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>lnb_lo</value></param>
<param><key>value</key><value>9.75e9</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>lo_xmit</value></param>
<param><key>comment</key><value>LOOP Back Value - or Ground to Ground x-band

4.8105 + 0.8495 = 5.66 GHz</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>4.8105e9</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>lo_xmit</value></param>
<param><key>comment</key><value>= 0 , No offset in transmitter for Demo

Offset for C-Band requires external LO for this card

Card Range 0.4 to 4.4 GHz

EX: 3.5 GHz LO would allow 3.9 to 7.9 GHz output</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable_low_pass_filter_taps</key>
<param><key>id</key><value>low_pass_filter_taps_output</value></param>
<param><key>cutoff_freq</key><value>128e3/2</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>samp_rate</key><value>samp_rate_sr2</value></param>
<param><key>width</key><value>(0.1)*128e3</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>variable_low_pass_filter_taps</key>
<param><key>id</key><value>lpf_taps</value></param>
<param><key>cutoff_freq</key><value>samp_rate_sr1/64</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>samp_rate</key><value>samp_rate_sr1/4</value></param>
<param><key>width</key><value>0.1*samp_rate_sr1/64</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>nbfm_rcv_freq_offset</value></param>
<param><key>value</key><value>-9.e3</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>7,2,1,1</value></param>
<param><key>label</key><value>nbfm rcv freq offset</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-samp_rate_sr2/8</value></param>
<param><key>step</key><value>100</value></param>
<param><key>stop</key><value>+samp_rate_sr2/8</value></param>
<param><key>widget</key><value>counter</value></param>
</block>
<block>
<key>variable_low_pass_filter_taps</key>
<param><key>id</key><value>nbfm_xlate_filter_taps_0</value></param>
<param><key>comment</key><value>Wider than needed for now</value></param>
<param><key>cutoff_freq</key><value>3.8e3*4</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>samp_rate</key><value>samp_rate_sr1/2</value></param>
<param><key>width</key><value>1600</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>num_chans</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>32-1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>num_chans</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>7</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>offset_temp</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>offset_tone_freq</value></param>
<param><key>value</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>label</key><value>Offset Lock Tone Frequency</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>offset_tone_freq</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>oversampled_width</value></param>
<param><key>comment</key><value>chan_width * (chans + 1)



3200*(7+1)=25.6kHz</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>2*chan_width * (num_chans + 1)</value></param>
</block>
<block>
<key>variable_low_pass_filter_taps</key>
<param><key>id</key><value>pfb_taps_0</value></param>
<param><key>cutoff_freq</key><value>xmit_channel_width</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gain</key><value>2.0</value></param>
<param><key>samp_rate</key><value>oversampled_width</value></param>
<param><key>width</key><value>2500</value></param>
<param><key>win</key><value>firdes.WIN_BLACKMAN</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>probed_det_freq_error</value></param>
<param><key>block_id</key><value>freq_error_det_0</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>200</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>probed_det_freq_error_with_old</value></param>
<param><key>block_id</key><value>freq_error_det</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>200</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>pseudo_doppler</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>sdr_st1_controls@2: 0,0,1,1</value></param>
<param><key>label0</key><value>Zero Doppler</value></param>
<param><key>label1</key><value>MEO+ +/- 50 kHz</value></param>
<param><key>label2</key><value>MEO  +/- 150 kHz</value></param>
<param><key>label3</key><value>LEO  +/- 250 kHz</value></param>
<param><key>label</key><value>Pseudo Doppler</value></param>
<param><key>num_opts</key><value>4</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>option1</key><value>1</value></param>
<param><key>option2</key><value>2</value></param>
<param><key>option3</key><value>3</value></param>
<param><key>orient</key><value>Qt.QHBoxLayout</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_low_pass_filter_taps</key>
<param><key>id</key><value>psk31_xlate_filter_taps_0</value></param>
<param><key>cutoff_freq</key><value>.7e3</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>samp_rate</key><value>samp_rate_sr2/16</value></param>
<param><key>width</key><value>300</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_UHD</value></param>
<param><key>value</key><value>samp_rate_sr1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_sr1</value></param>
<param><key>value</key><value>100.e6/100</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_sr2</value></param>
<param><key>value</key><value>samp_rate_sr1</value></param>
</block>
<block>
<key>variable_low_pass_filter_taps</key>
<param><key>id</key><value>sb_xlate_filter_taps_0</value></param>
<param><key>cutoff_freq</key><value>3.8e3/4</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>samp_rate</key><value>samp_rate_sr2/16</value></param>
<param><key>width</key><value>70</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sr1_atten_linear</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>1/(10**(-atten_in_dB/20.))</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>sr1_freq</value></param>
<param><key>comment</key><value>1339.2e6 = 446.4e6*3  1265e6
Assigned Satellite bands

145.80-146.00 x 1e6
144.30-144.50 x 1e6

435.0 - 438.0 x 1e6

1260.0-1270.0 x 1e6 Up-Link Only

2400.0-2403.0 x 1e6

3400.0	3410.0 x 1e6

5650.0-5670.0  x 1e6  Up-Link Only
5830.0-5850.0	 x 1e6  Down-Link Only

10450.0-10500.0 x 1e6  Space, Earth &amp; Tele

24.0-24.05 x 1e9
47.0-47.2 x 1e9
76.0-81.0 x 1e9
134.0-141.0 x 1e9
241.0-250.0 x1e9
Use a telescope !</value></param>
<param><key>value</key><value>446.4e6</value></param>
<param><key>gui_hint</key><value>sdr_sr1_controls@0: 0,0,1,1</value></param>
<param><key>label</key><value>Frequency</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>sr1_gain</value></param>
<param><key>value</key><value>1.0</value></param>
<param><key>gui_hint</key><value>sdr_sr1_controls@2: 0,0,1,1</value></param>
<param><key>label</key><value>RF Gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0.0</value></param>
<param><key>step</key><value>1.0</value></param>
<param><key>stop</key><value>50</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>sr1_rit</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>sdr_sr1_controls@1: 0,0,1,1</value></param>
<param><key>label</key><value>"SR1 Receiver RIT"</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-30000</value></param>
<param><key>step</key><value>5.0</value></param>
<param><key>stop</key><value>30000</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>sr1_sq_thres_config</value></param>
<param><key>config_file</key><value>default</value></param>
<param><key>value</key><value>-12</value></param>
<param><key>option</key><value>Min Squelch Level sr1</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>sr1_sq_thres_min</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>sr1_sq_thres_min</value></param>
<param><key>value</key><value>sr1_sq_thres_config</value></param>
<param><key>gui_hint</key><value>sdr_sr1_controls@3: 0,0,1,1</value></param>
<param><key>label</key><value>SR1 min SQ in dB</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-100</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>0</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>sr2_freq_offset</value></param>
<param><key>comment</key><value>-9kHz for the sat nbfm

when you read an error of + 1000 Hz
                          then set RIT to  -1000 Hz</value></param>
<param><key>value</key><value>4500</value></param>
<param><key>gui_hint</key><value>rtl_sdr_1_controls@1: 0,0,1,1</value></param>
<param><key>label</key><value>"SR2 RIT "</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-200000</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>200000</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>sr2_ppm</value></param>
<param><key>value</key><value>-2.0</value></param>
<param><key>gui_hint</key><value>rtl_sdr_1_controls@4: 0,0,1,1</value></param>
<param><key>label</key><value>SR2 ppm</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-100</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>100</value></param>
<param><key>widget</key><value>counter</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>sr2_rcv_rf_tun_gain</value></param>
<param><key>value</key><value>30</value></param>
<param><key>gui_hint</key><value>rtl_sdr_1_controls@2: 0,0,1,1</value></param>
<param><key>label</key><value>SR2 Receiver Gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>45</value></param>
<param><key>widget</key><value>counter</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>sr2_rcv_rf_tun_gain_if</value></param>
<param><key>value</key><value>20.0</value></param>
<param><key>gui_hint</key><value>rtl_sdr_1_controls@3: 0,0,1,1</value></param>
<param><key>label</key><value>SR2 Receiver IF Gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0.0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>45.0</value></param>
<param><key>widget</key><value>counter</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>sr2_rcv_tun_freq</value></param>
<param><key>comment</key><value>0.45e9+lnb_lo  for 146.52 no lo use 9896520000
Assigned Satellite bands

145.80-146.00 x 1e6
144.30-144.50 x 1e6

435.0 - 438.0 x 1e6

1260.0-1270.0 x 1e6

2400.0-2410.0 x 1e6

3400.0	3410.0 x 1e6

5650.0-5670.0  x 1e6  Up-Link Only
5830.0-5850.0	 x 1e6  Down-Link Only

10450.0-10500.0 x 1e6  Space, Earth &amp; Tele</value></param>
<param><key>value</key><value>10200000000.</value></param>
<param><key>gui_hint</key><value>rtl_sdr_1_controls@0: 0,0,1,1</value></param>
<param><key>label</key><value>SR2 Rcvr Freq (Hz)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>70e6+lnb_lo</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>1700.0e6+lnb_lo</value></param>
<param><key>widget</key><value>counter</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>sr2_sq_thres_config</value></param>
<param><key>config_file</key><value>default</value></param>
<param><key>value</key><value>-12</value></param>
<param><key>option</key><value>Min Squelch Level sr2</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>sr2_sq_thres_min</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>sr2_sq_thres_min</value></param>
<param><key>value</key><value>sr2_sq_thres_config</value></param>
<param><key>gui_hint</key><value>rtl_sdr_1_controls@5: 0,0,1,1</value></param>
<param><key>label</key><value>SR2 min SQ in dB</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-100</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>0</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>st1_freq</value></param>
<param><key>comment</key><value>Assigned Satellite bands  718.0e6
test @446.3e6+lo_xmit

145.80-146.00 x 1e6
144.30-144.50 x 1e6

435.0 - 438.0 x 1e6

1260.0-1270.0 x 1e6 Up-Link Only

2400.0-2403.0 x 1e6

3400.0	3410.0 x 1e6

5650.0-5670.0  x 1e6  Up-Link Only
5830.0-5850.0	 x 1e6  Down-Link Only

10450.0-10500.0 x 1e6  Space, Earth &amp; Tele

24.0-24.05 x 1e9
47.0-47.2 x 1e9
76.0-81.0 x 1e9
134.0-141.0 x 1e9
241.0-250.0 x1e9
Use a telescope !</value></param>
<param><key>value</key><value>446.3e6+lo_xmit</value></param>
<param><key>gui_hint</key><value>sdr_st1_controls@0: 0,0,1,1</value></param>
<param><key>label</key><value>Frequency</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>st1_gain</value></param>
<param><key>value</key><value>25.0</value></param>
<param><key>gui_hint</key><value>sdr_st1_controls@1: 0,0,1,1</value></param>
<param><key>label</key><value>RF Gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0.0</value></param>
<param><key>step</key><value>1.0</value></param>
<param><key>stop</key><value>50</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>tcp_qtgui_entry</value></param>
<param><key>value</key><value>"192.168.8.10"</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>6,3,1,1</value></param>
<param><key>label</key><value>IP Addr</value></param>
<param><key>type</key><value>raw</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>test_input_at_baseband</value></param>
<param><key>value</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>2,3,1,1</value></param>
<param><key>label</key><value>test_input_at_baseband</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-130e3</value></param>
<param><key>step</key><value>1000</value></param>
<param><key>stop</key><value>130e3</value></param>
<param><key>widget</key><value>counter</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>test_signal_input</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>sdr_st1_controls@3: 0,0,1,1</value></param>
<param><key>label0</key><value>Test Signal at 1 kHz</value></param>
<param><key>label1</key><value>Wide Band Noise ~ -20 dB</value></param>
<param><key>label2</key><value>Sweep Across Band</value></param>
<param><key>label</key><value>Test Input</value></param>
<param><key>num_opts</key><value>3</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>option1</key><value>1</value></param>
<param><key>option2</key><value>2</value></param>
<param><key>orient</key><value>Qt.QHBoxLayout</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>tun_freq</value></param>
<param><key>value</key><value>5651.50e6</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>label</key><value>Transmit Freq (Hz)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>5650.2e6</value></param>
<param><key>step</key><value>.1e3</value></param>
<param><key>stop</key><value>5924.8e6</value></param>
<param><key>widget</key><value>counter</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>tun_gain</value></param>
<param><key>value</key><value>10</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>3,1,1,1</value></param>
<param><key>label</key><value>UHD Tx Power Gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>20</value></param>
<param><key>widget</key><value>counter</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>voice_gain</value></param>
<param><key>value</key><value>.3</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>6,1,1,1</value></param>
<param><key>label</key><value>Audio Gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>.05</value></param>
<param><key>stop</key><value>1</value></param>
</block>
<block>
<key>variable_low_pass_filter_taps</key>
<param><key>id</key><value>wide_xlate_filter_taps_0</value></param>
<param><key>cutoff_freq</key><value>(256*.95)*1e3/4</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>samp_rate</key><value>samp_rate_sr2</value></param>
<param><key>width</key><value>0.05*(256e3)</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>analog_agc2_xx</key>
<param><key>id</key><value>analog_agc2_xx_0_0</value></param>
<param><key>attack_rate</key><value>1e-1</value></param>
<param><key>decay_rate</key><value>1e-2</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>max_gain</key><value>160</value></param>
<param><key>reference</key><value>1.0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>analog_agc2_xx</key>
<param><key>id</key><value>analog_agc2_xx_0_0_0_2</value></param>
<param><key>attack_rate</key><value>1e-1</value></param>
<param><key>decay_rate</key><value>1e-2</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>max_gain</key><value>65.536</value></param>
<param><key>reference</key><value>1.0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>analog_agc2_xx</key>
<param><key>id</key><value>analog_agc2_xx_0_0_0_2_0</value></param>
<param><key>attack_rate</key><value>1e-1</value></param>
<param><key>decay_rate</key><value>.02</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>max_gain</key><value>655.36</value></param>
<param><key>reference</key><value>1.0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0</value></param>
<param><key>const</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0_0</value></param>
<param><key>const</key><value>1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0_0_0</value></param>
<param><key>const</key><value>probed_det_freq_error_with_old</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0_0_0_0</value></param>
<param><key>const</key><value>probed_det_freq_error_with_old</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0_0_0_0_0</value></param>
<param><key>const</key><value>probed_det_freq_error_with_old</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0_0_1</value></param>
<param><key>const</key><value>probed_det_freq_error</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0_1</value></param>
<param><key>const</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_1</value></param>
<param><key>const</key><value>1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>analog_fastnoise_source_x</key>
<param><key>id</key><value>analog_fastnoise_source_x_1</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>noise_type</key><value>analog.GR_GAUSSIAN</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>seed</key><value>0</value></param>
<param><key>samples</key><value>8192</value></param>
</block>
<block>
<key>analog_fm_demod_cf</key>
<param><key>id</key><value>analog_fm_demod_cf_0</value></param>
<param><key>audio_decim</key><value>8</value></param>
<param><key>audio_pass</key><value>1200</value></param>
<param><key>audio_stop</key><value>3000</value></param>
<param><key>chan_rate</key><value>samp_rate_sr2/4</value></param>
<param><key>deviation</key><value>250000</value></param>
<param><key>gain</key><value>100</value></param>
<param><key>tau</key><value>0.0</value></param>
</block>
<block>
<key>analog_fm_demod_cf</key>
<param><key>id</key><value>analog_fm_demod_cf_1</value></param>
<param><key>audio_pass</key><value>15000</value></param>
<param><key>audio_stop</key><value>16000</value></param>
<param><key>deviation</key><value>75000</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>tau</key><value>75e-6</value></param>
</block>
<block>
<key>analog_nbfm_rx</key>
<param><key>id</key><value>analog_nbfm_rx_2</value></param>
<param><key>audio_rate</key><value>int(samp_rate_sr2/4/4)</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>max_dev</key><value>5.e3</value></param>
<param><key>quad_rate</key><value>int(samp_rate_sr2/4/4)</value></param>
<param><key>tau</key><value>75e-6</value></param>
</block>
<block>
<key>analog_nbfm_rx</key>
<param><key>id</key><value>analog_nbfm_rx_2_0</value></param>
<param><key>audio_rate</key><value>int(samp_rate_sr1/16)</value></param>
<param><key>comment</key><value>audio was int(samp_rate_sr1/16)/5</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>max_dev</key><value>6.66e3</value></param>
<param><key>quad_rate</key><value>int(samp_rate_sr1/16)</value></param>
<param><key>tau</key><value>75e-6</value></param>
</block>
<block>
<key>analog_nbfm_tx</key>
<param><key>id</key><value>analog_nbfm_tx_0_0</value></param>
<param><key>audio_rate</key><value>int(samp_rate_sr1/16)</value></param>
<param><key>comment</key><value>audio was int(samp_rate_sr1/16)/5</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>max_dev</key><value>6.66e3</value></param>
<param><key>fh</key><value>-1.0</value></param>
<param><key>quad_rate</key><value>int(samp_rate_sr1/16)</value></param>
<param><key>tau</key><value>75e-6</value></param>
</block>
<block>
<key>analog_pwr_squelch_xx</key>
<param><key>id</key><value>analog_pwr_squelch_xx_0_0_0</value></param>
<param><key>alpha</key><value>.001</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gate</key><value>False</value></param>
<param><key>ramp</key><value>1</value></param>
<param><key>threshold</key><value>(sr1_sq_thres_min)</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>analog_pwr_squelch_xx</key>
<param><key>id</key><value>analog_pwr_squelch_xx_0_0_1</value></param>
<param><key>alpha</key><value>.001</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gate</key><value>False</value></param>
<param><key>ramp</key><value>1</value></param>
<param><key>threshold</key><value>(sr2_sq_thres_min)</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>analog_rail_ff</key>
<param><key>id</key><value>analog_rail_ff_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>hi</key><value>+.707</value></param>
<param><key>lo</key><value>-.707</value></param>
</block>
<block>
<key>analog_rail_ff</key>
<param><key>id</key><value>analog_rail_ff_0_0</value></param>
<param><key>hi</key><value>10000</value></param>
<param><key>lo</key><value>-10000</value></param>
</block>
<block>
<key>analog_rail_ff</key>
<param><key>id</key><value>analog_rail_ff_0_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>hi</key><value>+.707</value></param>
<param><key>lo</key><value>-.707</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>freq</key><value>9000</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate_sr2</value></param>
<param><key>waveform</key><value>analog.GR_CONST_WAVE</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>freq</key><value>0</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate_sr2</value></param>
<param><key>waveform</key><value>analog.GR_CONST_WAVE</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0_0_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>-offset_tone_freq</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate_sr2/4</value></param>
<param><key>waveform</key><value>analog.GR_CONST_WAVE</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0_0_0_0_0</value></param>
<param><key>amp</key><value>1e-2</value></param>
<param><key>freq</key><value>offset_tone_freq</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate_sr2/4</value></param>
<param><key>waveform</key><value>analog.GR_CONST_WAVE</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_1</value></param>
<param><key>amp</key><value>1e-6</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>freq</key><value>test_input_at_baseband</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate_sr1</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_1_1</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>1e3</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate_sr1</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_1_1_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>offset_temp</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate_sr1/4</value></param>
<param><key>waveform</key><value>analog.GR_CONST_WAVE</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_2</value></param>
<param><key>amp</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>freq</key><value>2**16</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate_sr2</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samp_rate</key><value>48000</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0_2</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samp_rate</key><value>48000</value></param>
</block>
<block>
<key>band_pass_filter</key>
<param><key>id</key><value>band_pass_filter_0</value></param>
<param><key>beta</key><value>6.76</value></param>
<param><key>decim</key><value>2</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>high_cutoff_freq</key><value>offset_tone_freq+10e3</value></param>
<param><key>low_cutoff_freq</key><value>offset_tone_freq-10e3</value></param>
<param><key>samp_rate</key><value>266666.000274</value></param>
<param><key>width</key><value>10e3</value></param>
<param><key>win</key><value>firdes.WIN_KAISER</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>blks2_selector_0_0</value></param>
<param><key>input_index</key><value>pseudo_doppler</value></param>
<param><key>num_inputs</key><value>4</value></param>
<param><key>num_outputs</key><value>1</value></param>
<param><key>output_index</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>blks2_selector_0_1</value></param>
<param><key>input_index</key><value>enable_feedback</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>num_outputs</key><value>1</value></param>
<param><key>output_index</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>blks2_selector_0_1_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>input_index</key><value>enable_feedback</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>num_outputs</key><value>1</value></param>
<param><key>output_index</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>blks2_selector_0_2</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>input_index</key><value>audio_selection</value></param>
<param><key>num_inputs</key><value>5</value></param>
<param><key>num_outputs</key><value>1</value></param>
<param><key>output_index</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>blks2_selector_1</value></param>
<param><key>input_index</key><value>test_signal_input</value></param>
<param><key>num_inputs</key><value>3</value></param>
<param><key>num_outputs</key><value>1</value></param>
<param><key>output_index</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blks2_tcp_sink</key>
<param><key>id</key><value>blks2_tcp_sink_0</value></param>
<param><key>addr</key><value>tcp_qtgui_entry</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>server</key><value>False</value></param>
<param><key>port</key><value>88</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_4</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_inputs</key><value>3</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_1</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_2</value></param>
</block>
<block>
<key>blocks_float_to_char</key>
<param><key>id</key><value>blocks_float_to_char_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_1</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0</value></param>
<param><key>const</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0_2</value></param>
<param><key>const</key><value>voice_gain</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1</value></param>
<param><key>const</key><value>gr2_atten_linear</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1_0</value></param>
<param><key>const</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1_1</value></param>
<param><key>const</key><value>1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_2</value></param>
<param><key>const</key><value>sr1_atten_linear</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_2_0</value></param>
<param><key>const</key><value>1.0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_3</value></param>
<param><key>comment</key><value>Input to tone lock</value></param>
<param><key>const</key><value>1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_4</value></param>
<param><key>const</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_5</value></param>
<param><key>comment</key><value>0.07   for best linearity</value></param>
<param><key>const</key><value>.07</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0_1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_2</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_3</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_4</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_1_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_2</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_null_source</key>
<param><key>id</key><value>blocks_null_source_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_null_source</key>
<param><key>id</key><value>blocks_null_source_0_1</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_null_source</key>
<param><key>id</key><value>blocks_null_source_1</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_source</key>
<param><key>id</key><value>blocks_null_source_2</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_probe_rate</key>
<param><key>id</key><value>blocks_probe_rate_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>mintime</key><value>500.0</value></param>
<param><key>alpha</key><value>0.15</value></param>
</block>
<block>
<key>blocks_sample_and_hold_xx</key>
<param><key>id</key><value>blocks_sample_and_hold_xx_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_vco_c</key>
<param><key>id</key><value>blocks_vco_c_0</value></param>
<param><key>amplitude</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate_sr2</value></param>
<param><key>sensitivity</key><value>2*(22/7)*(2*50e3)</value></param>
</block>
<block>
<key>blocks_vco_c</key>
<param><key>id</key><value>blocks_vco_c_0_0</value></param>
<param><key>amplitude</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate_sr2</value></param>
<param><key>sensitivity</key><value>2*(22/7)*(2*150e3)</value></param>
</block>
<block>
<key>blocks_vco_c</key>
<param><key>id</key><value>blocks_vco_c_0_1</value></param>
<param><key>amplitude</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate_sr2</value></param>
<param><key>sensitivity</key><value>2*(22/7)*(2*250e3)</value></param>
</block>
<block>
<key>blocks_vco_c</key>
<param><key>id</key><value>blocks_vco_c_0_2</value></param>
<param><key>amplitude</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate_sr1</value></param>
<param><key>sensitivity</key><value>2*(22/7)*(2*130e3)</value></param>
</block>
<block>
<key>blocks_vco_c</key>
<param><key>id</key><value>blocks_vco_c_0_2_0</value></param>
<param><key>amplitude</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate_sr2/4</value></param>
<param><key>sensitivity</key><value>-(22/7)*(502./3)*1.25*2*1.52*1.6*3*1.6</value></param>
</block>
<block>
<key>blocks_vco_c</key>
<param><key>id</key><value>blocks_vco_c_0_2_0_0</value></param>
<param><key>amplitude</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samp_rate</key><value>samp_rate_sr2/4</value></param>
<param><key>sensitivity</key><value>-(22/7)*(502./3)*(st1_freq/sr2_rcv_tun_freq) </value></param>
</block>
<block>
<key>blocks_wavfile_source</key>
<param><key>id</key><value>blocks_wavfile_source_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/ray/Desktop/CQC/WA1CYB_on_Ch0.wav</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>dc_blocker_xx</key>
<param><key>id</key><value>dc_blocker_xx_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>length</key><value>4</value></param>
<param><key>long_form</key><value>True</value></param>
<param><key>type</key><value>ff</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>delta_freq_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_NONE</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label1</key><value>Held Value Out of S/H</value></param>
<param><key>color2</key><value>("blue", "red")</value></param>
<param><key>label2</key><value>probed_det_freq_error_to_SDR Freq Ctrl</value></param>
<param><key>label3</key><value>freq error RAW into S/H</value></param>
<param><key>max</key><value>10e3</value></param>
<param><key>min</key><value>-10e3</value></param>
<param><key>name</key><value>"Comp. Freq. Error - Hz"</value></param>
<param><key>nconnections</key><value>3</value></param>
<param><key>update_time</key><value>1/100.</value></param>
</block>
<block>
<key>blocks_probe_signal_x</key>
<param><key>id</key><value>freq_error_det</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_probe_signal_x</key>
<param><key>id</key><value>freq_error_det_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>freq_xlating_fft_filter_ccc</key>
<param><key>id</key><value>freq_xlating_fft_filter_ccc_0</value></param>
<param><key>center_freq</key><value>nbfm_rcv_freq_offset</value></param>
<param><key>comment</key><value>Use the FFT filter here rather than
the FIR since the FFT runs in almost
constant time and the FIR is linear
with the number of taps.</value></param>
<param><key>decim</key><value>4</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samp_rate</key><value>samp_rate_sr1/4</value></param>
<param><key>taps</key><value>lpf_taps</value></param>
</block>
<block>
<key>freq_xlating_fft_filter_ccc</key>
<param><key>id</key><value>freq_xlating_fft_filter_ccc_0_0</value></param>
<param><key>center_freq</key><value>-30.e3</value></param>
<param><key>comment</key><value>Use the FFT filter here rather than
the FIR since the FFT runs in almost
constant time and the FIR is linear
with the number of taps.</value></param>
<param><key>decim</key><value>4</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samp_rate</key><value>samp_rate_sr1/4</value></param>
<param><key>taps</key><value>bpf_taps</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>from math import sqrt</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>cutoff_freq</key><value>10e3</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate_sr2</value></param>
<param><key>width</key><value>3e3</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0_2</value></param>
<param><key>comment</key><value>audio was int(samp_rate_sr1/16)/5</value></param>
<param><key>cutoff_freq</key><value>3e3</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fir_filter_fff</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>int(samp_rate_sr1/16)</value></param>
<param><key>width</key><value>300</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0_2_0</value></param>
<param><key>cutoff_freq</key><value>5e3</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fir_filter_fff</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>audio_rate</value></param>
<param><key>width</key><value>500</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0_2_0_2_0_0</value></param>
<param><key>cutoff_freq</key><value>6.6e3*2</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>int(samp_rate_sr1/16)</value></param>
<param><key>width</key><value>400</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0_2_0_2_0_0_0</value></param>
<param><key>cutoff_freq</key><value>3800*2</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>int(samp_rate_sr1/16)</value></param>
<param><key>width</key><value>800</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>note</key><value>freq. offset for nbfm channel</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>note</key><value>Recorded Msg Gen Area</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_1</value></param>
<param><key>note</key><value>rcvd sig + Pseudo Doppler</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_10</value></param>
<param><key>note</key><value>X-Band GR2 receiver after LNB</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_11</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>note</key><value>Bandwidth is ~62.5kHz</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_11_0</value></param>
<param><key>note</key><value>Bandwidth is ~250kHz</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_12</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>note</key><value>Sat nbfm</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_12_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>note</key><value>Sat usb/cw</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_13</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>note</key><value>Local HT</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_14</value></param>
<param><key>note</key><value>temp offset for DC and I/Q imbalance</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_15</value></param>
<param><key>note</key><value>Test Equipment Stack</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_16</value></param>
<param><key>note</key><value>X-Band Doppler Correction Frequency</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_17</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>note</key><value>X-Band Doppler</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_18</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>note</key><value>Complex Clipping</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_19</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>note</key><value>nbfm offset</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_1_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>note</key><value>Doppler Insertion</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_2</value></param>
<param><key>note</key><value>Corrected Spectrum Output</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_20</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>note</key><value>uplink Transmitter</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_21</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>note</key><value>(st1_freq/sr2_rcv_tun_freq) relative Doppler compensation</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_22</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>note</key><value>optional uplink Doppler Lock tone</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_23</value></param>
<param><key>note</key><value>USB</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_26</value></param>
<param><key>note</key><value>sensitivity set with altitude meo, leo etc</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_26_0</value></param>
<param><key>note</key><value>max deviation set with altitude meo, leo etc</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_3</value></param>
<param><key>note</key><value>SR1 == GR1,    SR2== GR2,  ST1== GT1</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_3_0</value></param>
<param><key>note</key><value>Pass Timeing</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_4</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>note</key><value>If minimal Doppler.. Use This</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_5</value></param>
<param><key>comment</key><value>For Doppler Out (Dout):

Doppler In 1 =&gt; Dout*(st1_freq/gr2_freq)

ex: Dout = Din*(Lband/xband freq)

Doppler transmitted is a smaller offset than the
 Doppler down-link received since the received 
frequency  is higher than the up-link frequency</value></param>
<param><key>note</key><value>Receive / Transmit Notes</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_5_1</value></param>
<param><key>comment</key><value>For Pseudo Doppler Out (PsDout):

Pseudo Doppler In 1 = PsDout*(sr1_freq/st1_freq)

PsDIn-sr1 = PSDout*(sr1_freq/st1_freq)
PsDIn-sr2= PSDout*(sr2_freq/st1_freq)</value></param>
<param><key>note</key><value>Transmit Output Doppler Switch</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_6</value></param>
<param><key>note</key><value>Reduce sensitivity here</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_6_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>note</key><value>nbfm side Voice Output</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_6_0_0</value></param>
<param><key>note</key><value>Additional Doppler</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_6_1</value></param>
<param><key>note</key><value>Pseudo Doppler Offset</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_7</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>note</key><value>Transmitter Parameters</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_7_0</value></param>
<param><key>note</key><value>freq_error_det_0 is the measurement, NEW</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_8</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>note</key><value>Place holder ONLY - this is s demo !</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_9</value></param>
<param><key>note</key><value>Local Receiver #1 - GR1</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>dc_offset_mode0</key><value>2</value></param>
<param><key>corr0</key><value>sr2_ppm</value></param>
<param><key>freq0</key><value>sr2_rcv_tun_freq-sr2_freq_offset-offset_temp-lnb_lo+123e3</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>sr2_rcv_rf_tun_gain_if</value></param>
<param><key>iq_balance_mode0</key><value>2</value></param>
<param><key>gain0</key><value>sr2_rcv_rf_tun_gain</value></param>
<param><key>comment</key><value>Valid sample rates
225,001 =&gt; 300,000   263158.001233 perferred
900,001 =&gt; 3,200,000 ( or 1,800,000 )</value></param>
<param><key>args</key><value></value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate_sr2</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>pfb_synthesizer_ccf</key>
<param><key>id</key><value>pfb_synthesizer_ccf_0</value></param>
<param><key>twox</key><value>False</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>ch_map</key><value>chan_map_out</value></param>
<param><key>numchans</key><value>num_chans+1</value></param>
<param><key>connections</key><value>num_chans+1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>taps</key><value>pfb_taps</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>pseudo_doppler_source</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>comment</key><value>0 min pass =&gt; 1200 sec period
1 pass = 1/2 period

framp= 1/600 ideally

BUT    VCO has a  20kHz/16 sec max rate
400 sec for 500 kHz swing

W/ 533.33 kHz samp rate, max # is about 8150
w/ 266.666 kHz rate, max number is about 16100
w/1e6..max number is about 4295</value></param>
<param><key>freq</key><value>4.2/4000</value></param>
<param><key>offset</key><value>-.5</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>samp_rate_sr2</value></param>
<param><key>waveform</key><value>analog.GR_TRI_WAVE</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>pseudo_doppler_source_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>comment</key><value>60 sec sweep  framp= 1./60
30 sec sweep framp = (1./60)*2</value></param>
<param><key>freq</key><value>(1./60)/2</value></param>
<param><key>offset</key><value>-.5</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>samp_rate_sr2</value></param>
<param><key>waveform</key><value>analog.GR_TRI_WAVE</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate_sr1/4</value></param>
<param><key>fc</key><value>sr1_freq+sr1_rit</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>3,1,1,2</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>name</key><value>"GR1 Local Input"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymax</key><value>0</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0_0</value></param>
<param><key>bw</key><value>samp_rate_sr2</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>comment</key><value>sr2_rcv_tun_freq+sr2_freq_offset</value></param>
<param><key>fftsize</key><value>1024*8*2-1</value></param>
<param><key>gui_hint</key><value>1,1,1,3</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>label1</key><value>After 1kHz tone + input w/ pseudo Dopp</value></param>
<param><key>label2</key><value>Pseudo Doppler</value></param>
<param><key>label3</key><value>Corrected Input (after subtraction)</value></param>
<param><key>width3</key><value>2</value></param>
<param><key>label4</key><value>Doppler Detected</value></param>
<param><key>color5</key><value>"magenta"</value></param>
<param><key>label5</key><value>Tone input</value></param>
<param><key>name</key><value>"GR2 (LNB) Input"</value></param>
<param><key>nconnections</key><value>5</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymax</key><value>0</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_1</value></param>
<param><key>bw</key><value>samp_rate_sr2/4/25</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>comment</key><value>was 1,3,1,1</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>3,1,1,2</value></param>
<param><key>name</key><value>"Center Lock"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymax</key><value>0</value></param>
<param><key>ymin</key><value>-150</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_2</value></param>
<param><key>bw</key><value>samp_rate_sr2/4/8</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>label1</key><value>From FM demod</value></param>
<param><key>label2</key><value>S/H out</value></param>
<param><key>label3</key><value>VCO out- REAL</value></param>
<param><key>nconnections</key><value>3</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>float</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_2_0</value></param>
<param><key>bw</key><value>samp_rate_sr1</value></param>
<param><key>fc</key><value>st1_freq</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>7,0,1,2</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>label1</key><value>pre ettus pwr reduction</value></param>
<param><key>name</key><value>"Uplink Xmtr Input Spectrum"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymax</key><value>0</value></param>
<param><key>ymin</key><value>-90</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_3_1</value></param>
<param><key>bw</key><value>samp_rate_sr1/4/4/2</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>7,3,1,1</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>label2</key><value></value></param>
<param><key>name</key><value>"LNB RF nbfm"</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>float</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>label</key><value>Relative Gain in dB</value></param>
<param><key>ymax</key><value>0</value></param>
<param><key>units</key><value></value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_4_0_0_0</value></param>
<param><key>bw</key><value>samp_rate_sr2/4</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>1024*16-1</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>color1</key><value>"green"</value></param>
<param><key>name</key><value>"Offset Tone Spectrum"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>label</key><value>Relative Gain in dB</value></param>
<param><key>ymax</key><value>0</value></param>
<param><key>ymin</key><value>-120</value></param>
<param><key>units</key><value></value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate_sr2</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>comment</key><value>was 3,3,1,1</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>3,3,1,1</value></param>
<param><key>name</key><value>"Doppler Correction"</value></param>
<param><key>plotconst</key><value>False</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_1</value></param>
<param><key>bw</key><value>samp_rate_sr2</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>1,1,1,2</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0_0</value></param>
<param><key>bw</key><value>samp_rate_sr2</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>3,3,1,1</value></param>
<param><key>int_max</key><value>0</value></param>
<param><key>int_min</key><value>-120</value></param>
<param><key>name</key><value>"LNB Received"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0_1_0</value></param>
<param><key>bw</key><value>samp_rate_sr2/4/25</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>1,3,1,1</value></param>
<param><key>int_max</key><value>0</value></param>
<param><key>int_min</key><value>-50</value></param>
<param><key>name</key><value>"Ground Received"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>int(samp_rate_sr2/4/4)</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>interp</key><value>audio_rate</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0_0</value></param>
<param><key>decim</key><value>int(samp_rate_sr2/4/4)</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>interp</key><value>audio_rate</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0_0_0_0_0_0_0</value></param>
<param><key>decim</key><value>int(samp_rate_sr1/16)</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>interp</key><value>int(samp_rate_sr1)</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0_1</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>interp</key><value>4</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0_1_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>interp</key><value>4</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_1</value></param>
<param><key>decim</key><value>4</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_2</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_3</value></param>
<param><key>decim</key><value>25</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_3_0</value></param>
<param><key>decim</key><value>4</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_4</value></param>
<param><key>decim</key><value>int(samp_rate_sr1)</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>interp</key><value>int(samp_rate_sr1/4)</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_4_0</value></param>
<param><key>decim</key><value>int(samp_rate_sr1)</value></param>
<param><key>interp</key><value>int(samp_rate_sr1/4)</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_4_0_0</value></param>
<param><key>decim</key><value>int(samp_rate_sr2/4)</value></param>
<param><key>interp</key><value>int(samp_rate_sr2)</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_5</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>interp</key><value>4</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_6</value></param>
<param><key>comment</key><value>audio was int(samp_rate_sr1/16)/5</value></param>
<param><key>decim</key><value>int(samp_rate_sr1/16)</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>interp</key><value>48000</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_7</value></param>
<param><key>decim</key><value>int(samp_rate_sr2/4)</value></param>
<param><key>interp</key><value>int(samp_rate_sr2/32)</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>rtl_sdr_1_controls</value></param>
<param><key>gui_hint</key><value>0,2,1,1</value></param>
<param><key>label0</key><value>GR2 X-band Receiver Frequency </value></param>
<param><key>label1</key><value>GR2 RIT</value></param>
<param><key>label2</key><value>GR2 Receiver Gain</value></param>
<param><key>label3</key><value>GR2 Receiver IF Gain</value></param>
<param><key>label4</key><value>GR2 PPM</value></param>
<param><key>label5</key><value>GR2 Squelch</value></param>
<param><key>num_tabs</key><value>6</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>sdr_sr1_controls</value></param>
<param><key>gui_hint</key><value>0,1,1,1</value></param>
<param><key>label0</key><value>GR1 Local Receiver Frequency</value></param>
<param><key>label1</key><value>GR1 Local Receiver RIT</value></param>
<param><key>label2</key><value>GR1 Local Receiver Gain</value></param>
<param><key>label3</key><value>GR1 Local Squelch</value></param>
<param><key>num_tabs</key><value>4</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>sdr_st1_controls</value></param>
<param><key>gui_hint</key><value>0,3,1,1</value></param>
<param><key>label0</key><value>GT1 Transmit Frequency</value></param>
<param><key>label1</key><value>GT1 Transmit Gain</value></param>
<param><key>label2</key><value>Pseudo Doppler</value></param>
<param><key>label3</key><value>Test Signals</value></param>
<param><key>num_tabs</key><value>4</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>sdr_st1_controls_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>label0</key><value>ST1 Transmit Frequency</value></param>
<param><key>label1</key><value>ST1 Transmit Gain</value></param>
<param><key>label2</key><value>Pseudo Doppler</value></param>
<param><key>label3</key><value>VCO Gain</value></param>
<param><key>num_tabs</key><value>4</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>sr2_dc_iq_offset_0_1_1</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>freq</key><value>-9000.</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate_sr1</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>tab1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>0,3,1,1</value></param>
<param><key>label0</key><value>Tone Lock Spectrum</value></param>
<param><key>label1</key><value></value></param>
<param><key>num_tabs</key><value>2</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>center_freq0</key><value>st1_freq-lo_xmit</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>20</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>comment</key><value>US Ham Band coverage

XCVR2450 2.4 GHz-4.5 GHz, 4.9-5.9 GHz
2400-2450 MHz
3300-3500 MHz
5650-5925 MHz

SBX Daughterboard 400 MHz - 4.4 GHz
420- 450 MHz
902 - 928 MHz
1240-1300 MHz
2300-2310 MHz
2390-2450 MHz
3300-3500 MHz


WiFi type Reference for Interference
902-928 MHz(NA)  (802.11ah)
2412/2462(NA)-2484 MHz
3657.5-3692.5 MHz
4910-4990 MHz (Military)
5030/5170(NA)-5835(NA)/5875 MHz
5850–5925 MHz (NA ITS)</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate_sr1</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0_0</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>center_freq0</key><value>sr1_freq+sr1_rit</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>sr1_gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>comment</key><value>Target sample rate: 0.262144 MSps
Actual sample rate: 0.263158 MSps

US Ham Band coverage

XCVR2450 2.4 GHz-4.5 GHz, 4.9-5.9 GHz
2400-2450 MHz
3300-3500 MHz
5650-5925 MHz

SBX Daughterboard 400 MHz - 4.4 GHz
420- 450 MHz
902 - 928 MHz
1240-1300 MHz
2300-2310 MHz
2390-2450 MHz
3300-3500 MHz


WiFi type Reference for Interference
902-928 MHz(NA)  (802.11ah)
2412/2462(NA)-2484 MHz
3657.5-3692.5 MHz
4910-4990 MHz (Military)
5030/5170(NA)-5835(NA)/5875 MHz
5850–5925 MHz (NA ITS)</value></param>
<param><key>dev_addr</key><value></value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>sd_spec0</key><value>A:0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate*2</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value>pc_clock</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0_0_0</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>center_freq0</key><value>sr1_freq+sr1_rit-offset_temp</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>sr1_gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>comment</key><value>Target sample rate: 0.262144 MSps
Actual sample rate: 0.263158 MSps

US Ham Band coverage

XCVR2450 2.4 GHz-4.5 GHz, 4.9-5.9 GHz
2400-2450 MHz
3300-3500 MHz
5650-5925 MHz

SBX Daughterboard 400 MHz - 4.4 GHz
420- 450 MHz
902 - 928 MHz
1240-1300 MHz
2300-2310 MHz
2390-2450 MHz
3300-3500 MHz


WiFi type Reference for Interference
902-928 MHz(NA)  (802.11ah)
2412/2462(NA)-2484 MHz
3657.5-3692.5 MHz
4910-4990 MHz (Military)
5030/5170(NA)-5835(NA)/5875 MHz
5850–5925 MHz (NA ITS)</value></param>
<param><key>dev_addr</key><value></value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>sd_spec0</key><value>A:0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate_sr1</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value>pc_clock</value></param>
</block>
<connection><source_block_id>analog_agc2_xx_0_0</source_block_id><sink_block_id>analog_pwr_squelch_xx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_agc2_xx_0_0_0_2</source_block_id><sink_block_id>analog_pwr_squelch_xx_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_agc2_xx_0_0_0_2_0</source_block_id><sink_block_id>rational_resampler_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_const_source_x_0</source_block_id><sink_block_id>blks2_selector_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_const_source_x_0_0</source_block_id><sink_block_id>blks2_selector_0_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_const_source_x_0_0_0</source_block_id><sink_block_id>delta_freq_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_const_source_x_0_0_0_0</source_block_id><sink_block_id>blocks_vco_c_0_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_const_source_x_0_0_0_0_0</source_block_id><sink_block_id>blocks_vco_c_0_2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_const_source_x_0_0_1</source_block_id><sink_block_id>blocks_sample_and_hold_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_const_source_x_0_0_1</source_block_id><sink_block_id>delta_freq_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>analog_const_source_x_0_1</source_block_id><sink_block_id>blks2_selector_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_const_source_x_1</source_block_id><sink_block_id>blks2_selector_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_fastnoise_source_x_1</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_fm_demod_cf_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_fm_demod_cf_0</source_block_id><sink_block_id>qtgui_freq_sink_x_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_nbfm_rx_2</source_block_id><sink_block_id>dc_blocker_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_nbfm_rx_2</source_block_id><sink_block_id>qtgui_freq_sink_x_3_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_nbfm_rx_2_0</source_block_id><sink_block_id>analog_nbfm_tx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_nbfm_rx_2_0</source_block_id><sink_block_id>rational_resampler_xxx_6</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_nbfm_tx_0_0</source_block_id><sink_block_id>blocks_complex_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_pwr_squelch_xx_0_0_0</source_block_id><sink_block_id>analog_nbfm_rx_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_pwr_squelch_xx_0_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_4</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_pwr_squelch_xx_0_0_1</source_block_id><sink_block_id>analog_nbfm_rx_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_rail_ff_0</source_block_id><sink_block_id>blocks_float_to_complex_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_rail_ff_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_1_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_rail_ff_0_1</source_block_id><sink_block_id>blocks_float_to_complex_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0_0</source_block_id><sink_block_id>blks2_selector_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0_0_0</source_block_id><sink_block_id>blocks_multiply_xx_0_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0_0_0_0_0</source_block_id><sink_block_id>blocks_multiply_xx_2</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_1</source_block_id><sink_block_id>blocks_add_xx_4</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_1_1</source_block_id><sink_block_id>blks2_selector_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_1_1_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_2</source_block_id><sink_block_id>blocks_add_xx_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>band_pass_filter_0</source_block_id><sink_block_id>blocks_multiply_xx_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_0_0</source_block_id><sink_block_id>rational_resampler_xxx_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_0_1</source_block_id><sink_block_id>blocks_float_to_char_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_0_1_0</source_block_id><sink_block_id>blocks_multiply_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_0_2</source_block_id><sink_block_id>blks2_tcp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_0_2</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_1</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_1</source_block_id><sink_block_id>blocks_add_xx_4</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blks2_selector_1</source_block_id><sink_block_id>qtgui_freq_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>blocks_multiply_xx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_1</source_block_id><sink_block_id>blocks_multiply_const_vxx_5</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_1</source_block_id><sink_block_id>qtgui_freq_sink_x_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_4</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>analog_rail_ff_0_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>analog_rail_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_1</source_block_id><sink_block_id>blocks_null_sink_2</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_1</source_block_id><sink_block_id>blks2_selector_0_2</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_2</source_block_id><sink_block_id>qtgui_freq_sink_x_2</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_float_to_char_0</source_block_id><sink_block_id>blocks_sample_and_hold_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_1</source_block_id><sink_block_id>low_pass_filter_0_2_0_2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blks2_selector_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_2</source_block_id><sink_block_id>audio_sink_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_2</source_block_id><sink_block_id>blocks_probe_rate_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1</source_block_id><sink_block_id>rational_resampler_xxx_3_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1_0</source_block_id><sink_block_id>analog_agc2_xx_0_0_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1_1</source_block_id><sink_block_id>freq_error_det_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_2</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_2</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_2</source_block_id><sink_block_id>rational_resampler_xxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_2_0</source_block_id><sink_block_id>analog_rail_ff_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_3</source_block_id><sink_block_id>blocks_multiply_xx_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_3</source_block_id><sink_block_id>blocks_multiply_xx_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_4</source_block_id><sink_block_id>blocks_complex_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_5</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0_0</source_block_id><sink_block_id>blocks_add_xx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0_1</source_block_id><sink_block_id>analog_fm_demod_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0_1</source_block_id><sink_block_id>blocks_null_sink_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0_1</source_block_id><sink_block_id>qtgui_freq_sink_x_4_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_1</source_block_id><sink_block_id>qtgui_freq_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_1</source_block_id><sink_block_id>qtgui_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_1</source_block_id><sink_block_id>rational_resampler_xxx_4_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_2</source_block_id><sink_block_id>band_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_2</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_3</source_block_id><sink_block_id>rational_resampler_xxx_4_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_4</source_block_id><sink_block_id>blocks_multiply_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_null_source_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_null_source_0_1</source_block_id><sink_block_id>blks2_selector_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_null_source_1</source_block_id><sink_block_id>blocks_add_xx_4</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_null_source_2</source_block_id><sink_block_id>blocks_add_xx_4</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_probe_rate_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>rate</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>blocks_sample_and_hold_xx_0</source_block_id><sink_block_id>delta_freq_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_sample_and_hold_xx_0</source_block_id><sink_block_id>freq_error_det</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_sample_and_hold_xx_0</source_block_id><sink_block_id>qtgui_freq_sink_x_2</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_vco_c_0</source_block_id><sink_block_id>blks2_selector_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_vco_c_0_0</source_block_id><sink_block_id>blks2_selector_0_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_vco_c_0_1</source_block_id><sink_block_id>blks2_selector_0_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>blocks_vco_c_0_2</source_block_id><sink_block_id>blks2_selector_1</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_vco_c_0_2_0</source_block_id><sink_block_id>rational_resampler_xxx_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vco_c_0_2_0</source_block_id><sink_block_id>rational_resampler_xxx_5</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vco_c_0_2_0</source_block_id><sink_block_id>rational_resampler_xxx_7</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vco_c_0_2_0_0</source_block_id><sink_block_id>rational_resampler_xxx_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_wavfile_source_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dc_blocker_xx_0</source_block_id><sink_block_id>qtgui_freq_sink_x_3_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>dc_blocker_xx_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fft_filter_ccc_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fft_filter_ccc_0_0</source_block_id><sink_block_id>analog_agc2_xx_0_0_0_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>blocks_multiply_xx_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0_2_0</source_block_id><sink_block_id>blks2_selector_0_2</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>low_pass_filter_0_2_0</source_block_id><sink_block_id>blks2_selector_0_2</sink_block_id><source_key>0</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>low_pass_filter_0_2_0_2_0_0</source_block_id><sink_block_id>rational_resampler_xxx_0_0_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>pseudo_doppler_source</source_block_id><sink_block_id>blocks_vco_c_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pseudo_doppler_source</source_block_id><sink_block_id>blocks_vco_c_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pseudo_doppler_source</source_block_id><sink_block_id>blocks_vco_c_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pseudo_doppler_source_0</source_block_id><sink_block_id>blocks_vco_c_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>low_pass_filter_0_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0_0</source_block_id><sink_block_id>blocks_complex_to_float_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0_0_0_0_0_0_0</source_block_id><sink_block_id>blocks_multiply_xx_4</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0_1</source_block_id><sink_block_id>blocks_multiply_xx_3</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0_1_0</source_block_id><sink_block_id>blks2_selector_0_1_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_1</source_block_id><sink_block_id>analog_agc2_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_2</source_block_id><sink_block_id>blocks_multiply_xx_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_2</source_block_id><sink_block_id>qtgui_freq_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_3</source_block_id><sink_block_id>qtgui_freq_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_3</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_3_0</source_block_id><sink_block_id>freq_xlating_fft_filter_ccc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_3_0</source_block_id><sink_block_id>freq_xlating_fft_filter_ccc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_3_0</source_block_id><sink_block_id>rational_resampler_xxx_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_4</source_block_id><sink_block_id>blocks_add_xx_4</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_4_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_4_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_4_0_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_4_0_0</source_block_id><sink_block_id>qtgui_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_5</source_block_id><sink_block_id>qtgui_freq_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_6</source_block_id><sink_block_id>blks2_selector_0_2</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_6</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_7</source_block_id><sink_block_id>blocks_complex_to_float_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sr2_dc_iq_offset_0_1_1</source_block_id><sink_block_id>blocks_multiply_xx_4</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0_0_0</source_block_id><sink_block_id>rational_resampler_xxx_4</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
