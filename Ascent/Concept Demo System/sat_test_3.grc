<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>sat_test_3</value></param>
<param><key>author</key><value>WA1CYB</value></param>
<param><key>comment</key><value>Approx bw's and thresholds

Sat Test 3 Linear with Doppler,
Lock Tone &amp; ID+ nbfm+
linear channel + noise not overlapping nbfm !

CW with speed adjust.. my call</value></param>
<param><key>description</key><value>Sat Test 3 Linear channels with Doppler,Lock Tone &amp; ID+ nbfm+ channel shift</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>Sat Test 3</value></param>
</block>
<block>
<key>variable_low_pass_filter_taps</key>
<param><key>id</key><value>D9600_xlate_filter_taps_0</value></param>
<param><key>cutoff_freq</key><value>9.6e3/2</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>samp_rate</key><value>samp_rate_sr2/16</value></param>
<param><key>width</key><value>100</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>LO</value></param>
<param><key>value</key><value>2**16</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>ampl</value></param>
<param><key>value</key><value>0.05</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>label</key><value>Xmit Input Level</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.005</value></param>
<param><key>stop</key><value>.5</value></param>
<param><key>widget</key><value>counter</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>audio_rate</value></param>
<param><key>value</key><value>480000</value></param>
</block>
<block>
<key>variable_low_pass_filter_taps</key>
<param><key>id</key><value>band_xlate_filter_taps_0</value></param>
<param><key>cutoff_freq</key><value>256e3/4</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>samp_rate</key><value>samp_rate_sr1</value></param>
<param><key>width</key><value>0.1*(128e3)/2</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>variable_low_pass_filter_taps</key>
<param><key>id</key><value>cw_xlate_filter_taps_0</value></param>
<param><key>cutoff_freq</key><value>.4e3</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>samp_rate</key><value>samp_rate_sr2/16</value></param>
<param><key>width</key><value>100</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>variable_low_pass_filter_taps</key>
<param><key>id</key><value>half_band_xlate_filter_taps_0</value></param>
<param><key>cutoff_freq</key><value>64e3/2</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>samp_rate</key><value>samp_rate_sr1/2</value></param>
<param><key>width</key><value>5e3</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>variable_low_pass_filter_taps</key>
<param><key>id</key><value>low_pass_filter_taps_output</value></param>
<param><key>cutoff_freq</key><value>128e3/2</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>samp_rate</key><value>samp_rate_sr2</value></param>
<param><key>width</key><value>(0.1)*128e3</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>variable_low_pass_filter_taps</key>
<param><key>id</key><value>nbfm_xlate_filter_taps_0</value></param>
<param><key>comment</key><value>Wider than needed for now</value></param>
<param><key>cutoff_freq</key><value>3.8e3*4</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>samp_rate</key><value>samp_rate_sr1/2</value></param>
<param><key>width</key><value>1600</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>offset_temp</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>pseudo_doppler</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>sdr_st1_controls@2: 0,0,1,1</value></param>
<param><key>label0</key><value>Zero Doppler</value></param>
<param><key>label1</key><value>MEO+ +/- 50 kHz</value></param>
<param><key>label2</key><value>MEO  +/- 150 kHz</value></param>
<param><key>label3</key><value>LEO  +/- 250 kHz</value></param>
<param><key>label</key><value>Pseudo Doppler</value></param>
<param><key>num_opts</key><value>4</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>option1</key><value>1</value></param>
<param><key>option2</key><value>2</value></param>
<param><key>option3</key><value>3</value></param>
<param><key>orient</key><value>Qt.QHBoxLayout</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_low_pass_filter_taps</key>
<param><key>id</key><value>psk31_xlate_filter_taps_0</value></param>
<param><key>cutoff_freq</key><value>.7e3</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>samp_rate</key><value>samp_rate_sr2/16</value></param>
<param><key>width</key><value>300</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_UHD</value></param>
<param><key>value</key><value>samp_rate_sr1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_sr1</value></param>
<param><key>value</key><value>100.e6/100</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_sr2</value></param>
<param><key>value</key><value>samp_rate_sr1</value></param>
</block>
<block>
<key>variable_low_pass_filter_taps</key>
<param><key>id</key><value>sb_xlate_filter_taps_0</value></param>
<param><key>cutoff_freq</key><value>3.8e3/4</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>samp_rate</key><value>samp_rate_sr2/16</value></param>
<param><key>width</key><value>70</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>sr1_freq</value></param>
<param><key>comment</key><value>Assigned Satellite bands

145.80-146.00 x 1e6
144.30-144.50 x 1e6

435.0 - 438.0 x 1e6

1260.0-1270.0 x 1e6 Up-Link Only

2400.0-2403.0 x 1e6

3400.0	3410.0 x 1e6

5650.0-5670.0  x 1e6  Up-Link Only
5830.0-5850.0	 x 1e6  Down-Link Only

10450.0-10500.0 x 1e6  Space, Earth &amp; Tele

24.0-24.05 x 1e9
47.0-47.2 x 1e9
76.0-81.0 x 1e9
134.0-141.0 x 1e9
241.0-250.0 x1e9
Use a telescope !</value></param>
<param><key>value</key><value>1265e6</value></param>
<param><key>gui_hint</key><value>sdr_sr1_controls@0: 0,0,1,1</value></param>
<param><key>label</key><value>Frequency</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>sr1_gain</value></param>
<param><key>value</key><value>25.0</value></param>
<param><key>gui_hint</key><value>sdr_sr1_controls@2: 0,0,1,1</value></param>
<param><key>label</key><value>RF Gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0.0</value></param>
<param><key>step</key><value>1.0</value></param>
<param><key>stop</key><value>50</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>sr1_rit</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>sdr_sr1_controls@1: 0,0,1,1</value></param>
<param><key>label</key><value>"SR1 Receiver RIT"</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-30000</value></param>
<param><key>step</key><value>5.0</value></param>
<param><key>stop</key><value>30000</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>sr1_sq_thres_config</value></param>
<param><key>config_file</key><value>default</value></param>
<param><key>value</key><value>-12</value></param>
<param><key>option</key><value>Min Squelch Level sr1</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>sr1_sq_thres_min</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>sr1_sq_thres_min</value></param>
<param><key>value</key><value>sr1_sq_thres_config</value></param>
<param><key>gui_hint</key><value>sdr_sr1_controls@3: 0,0,1,1</value></param>
<param><key>label</key><value>SR1 min SQ in dB</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-100</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>0</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>sr2_freq_offset</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>rtl_sdr_1_controls@1: 0,0,1,1</value></param>
<param><key>label</key><value>"SR2 RIT "</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-20000</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>20000</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>sr2_ppm</value></param>
<param><key>value</key><value>18.0</value></param>
<param><key>gui_hint</key><value>rtl_sdr_1_controls@4: 0,0,1,1</value></param>
<param><key>label</key><value>SR2 ppm</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-100</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>100</value></param>
<param><key>widget</key><value>counter</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>sr2_rcv_rf_tun_gain</value></param>
<param><key>value</key><value>30</value></param>
<param><key>gui_hint</key><value>rtl_sdr_1_controls@2: 0,0,1,1</value></param>
<param><key>label</key><value>SR2 Receiver Gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>45</value></param>
<param><key>widget</key><value>counter</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>sr2_rcv_rf_tun_gain_if</value></param>
<param><key>value</key><value>20.0</value></param>
<param><key>gui_hint</key><value>rtl_sdr_1_controls@3: 0,0,1,1</value></param>
<param><key>label</key><value>SR2 Receiver IF Gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0.0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>45.0</value></param>
<param><key>widget</key><value>counter</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>sr2_rcv_tun_freq</value></param>
<param><key>comment</key><value>Assigned Satellite bands

145.80-146.00 x 1e6
144.30-144.50 x 1e6

435.0 - 438.0 x 1e6

1260.0-1270.0 x 1e6

2400.0-2410.0 x 1e6

3400.0	3410.0 x 1e6

5650.0-5670.0  x 1e6  Up-Link Only
5830.0-5850.0	 x 1e6  Down-Link Only

10450.0-10500.0 x 1e6  Space, Earth &amp; Tele</value></param>
<param><key>value</key><value>146.52e6</value></param>
<param><key>gui_hint</key><value>rtl_sdr_1_controls@0: 0,0,1,1</value></param>
<param><key>label</key><value>SR2 Rcvr Freq (Hz)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>70e6</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>1700.0e6</value></param>
<param><key>widget</key><value>counter</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>sr2_sq_thres_config</value></param>
<param><key>config_file</key><value>default</value></param>
<param><key>value</key><value>-12</value></param>
<param><key>option</key><value>Min Squelch Level sr2</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>sr2_sq_thres_min</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>sr2_sq_thres_min</value></param>
<param><key>value</key><value>sr2_sq_thres_config</value></param>
<param><key>gui_hint</key><value>rtl_sdr_1_controls@5: 0,0,1,1</value></param>
<param><key>label</key><value>SR2 min SQ in dB</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-100</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>0</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>st1_freq</value></param>
<param><key>comment</key><value>Assigned Satellite bands  718.0e6

145.80-146.00 x 1e6
144.30-144.50 x 1e6

435.0 - 438.0 x 1e6

1260.0-1270.0 x 1e6 Up-Link Only

2400.0-2403.0 x 1e6

3400.0	3410.0 x 1e6

5650.0-5670.0  x 1e6  Up-Link Only
5830.0-5850.0	 x 1e6  Down-Link Only

10450.0-10500.0 x 1e6  Space, Earth &amp; Tele

24.0-24.05 x 1e9
47.0-47.2 x 1e9
76.0-81.0 x 1e9
134.0-141.0 x 1e9
241.0-250.0 x1e9
Use a telescope !</value></param>
<param><key>value</key><value>446.3e6</value></param>
<param><key>gui_hint</key><value>sdr_st1_controls@0: 0,0,1,1</value></param>
<param><key>label</key><value>Frequency</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>st1_gain</value></param>
<param><key>value</key><value>25.0</value></param>
<param><key>gui_hint</key><value>sdr_st1_controls@1: 0,0,1,1</value></param>
<param><key>label</key><value>RF Gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0.0</value></param>
<param><key>step</key><value>1.0</value></param>
<param><key>stop</key><value>50</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>temp_atten_all_channels</value></param>
<param><key>value</key><value>1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>.0001</value></param>
<param><key>step</key><value>.0001</value></param>
<param><key>stop</key><value>1</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>tun_freq</value></param>
<param><key>value</key><value>5651.50e6</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>label</key><value>Transmit Freq (Hz)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>5650.2e6</value></param>
<param><key>step</key><value>.1e3</value></param>
<param><key>stop</key><value>5924.8e6</value></param>
<param><key>widget</key><value>counter</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>tun_gain</value></param>
<param><key>value</key><value>10</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>3,1,1,1</value></param>
<param><key>label</key><value>UHD Tx Power Gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>20</value></param>
<param><key>widget</key><value>counter</value></param>
</block>
<block>
<key>variable_low_pass_filter_taps</key>
<param><key>id</key><value>wide_xlate_filter_taps_0</value></param>
<param><key>cutoff_freq</key><value>(256*.95)*1e3/4</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>samp_rate</key><value>samp_rate_sr2</value></param>
<param><key>width</key><value>0.05*(256e3)</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>wpm</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>wpm_0</value></param>
<param><key>value</key><value>15</value></param>
</block>
<block>
<key>analog_agc2_xx</key>
<param><key>id</key><value>analog_agc2_xx_0_0</value></param>
<param><key>attack_rate</key><value>1e-1</value></param>
<param><key>decay_rate</key><value>1e-2</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>max_gain</key><value>16</value></param>
<param><key>reference</key><value>1.0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>analog_agc2_xx</key>
<param><key>id</key><value>analog_agc2_xx_0_0_0_2</value></param>
<param><key>attack_rate</key><value>1e-1</value></param>
<param><key>decay_rate</key><value>1e-2</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>max_gain</key><value>16</value></param>
<param><key>reference</key><value>1.0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>analog_ctcss_squelch_ff</key>
<param><key>id</key><value>analog_ctcss_squelch_ff_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gate</key><value>False</value></param>
<param><key>len</key><value>0</value></param>
<param><key>level</key><value>0.01</value></param>
<param><key>ramp</key><value>0</value></param>
<param><key>rate</key><value>int(samp_rate_sr1/16)</value></param>
<param><key>freq</key><value>100.0</value></param>
</block>
<block>
<key>analog_fastnoise_source_x</key>
<param><key>id</key><value>analog_fastnoise_source_x_1</value></param>
<param><key>amp</key><value>.01</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>noise_type</key><value>analog.GR_GAUSSIAN</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>seed</key><value>0</value></param>
<param><key>samples</key><value>8192</value></param>
</block>
<block>
<key>analog_nbfm_rx</key>
<param><key>id</key><value>analog_nbfm_rx_2_0</value></param>
<param><key>audio_rate</key><value>int(samp_rate_sr1/16)/5</value></param>
<param><key>max_dev</key><value>8.9e3</value></param>
<param><key>quad_rate</key><value>int(samp_rate_sr1/16)</value></param>
<param><key>tau</key><value>75e-6</value></param>
</block>
<block>
<key>analog_nbfm_tx</key>
<param><key>id</key><value>analog_nbfm_tx_0_0</value></param>
<param><key>audio_rate</key><value>int(samp_rate_sr1/16)/5</value></param>
<param><key>max_dev</key><value>8.9e3</value></param>
<param><key>fh</key><value>-1.0</value></param>
<param><key>quad_rate</key><value>int(samp_rate_sr1/16)</value></param>
<param><key>tau</key><value>75e-6</value></param>
</block>
<block>
<key>analog_pwr_squelch_xx</key>
<param><key>id</key><value>analog_pwr_squelch_xx_0_0_0</value></param>
<param><key>alpha</key><value>.001</value></param>
<param><key>gate</key><value>False</value></param>
<param><key>ramp</key><value>1</value></param>
<param><key>threshold</key><value>(sr1_sq_thres_min)</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>analog_pwr_squelch_xx</key>
<param><key>id</key><value>analog_pwr_squelch_xx_0_0_1</value></param>
<param><key>alpha</key><value>.001</value></param>
<param><key>gate</key><value>False</value></param>
<param><key>ramp</key><value>1</value></param>
<param><key>threshold</key><value>(sr1_sq_thres_min)</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>0</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate_sr2</value></param>
<param><key>waveform</key><value>analog.GR_CONST_WAVE</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>0</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate_sr2</value></param>
<param><key>waveform</key><value>analog.GR_CONST_WAVE</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0_0_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>freq</key><value>0</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate_sr2</value></param>
<param><key>waveform</key><value>analog.GR_CONST_WAVE</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_1_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>-30.5e3</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate_sr2</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>samp_rate</key><value>48000</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>blks2_selector_0</value></param>
<param><key>input_index</key><value>pseudo_doppler</value></param>
<param><key>num_inputs</key><value>4</value></param>
<param><key>num_outputs</key><value>1</value></param>
<param><key>output_index</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>blks2_selector_sr1</value></param>
<param><key>comment</key><value>SR1 Receiver selector switch

Sr1/St1 = frequency weighting</value></param>
<param><key>input_index</key><value>pseudo_doppler</value></param>
<param><key>num_inputs</key><value>4</value></param>
<param><key>num_outputs</key><value>1</value></param>
<param><key>output_index</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>blks2_selector_sr1_0</value></param>
<param><key>comment</key><value>SR2 Receiver selector switch

Sr2/St1 = frequency weighting</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>input_index</key><value>pseudo_doppler</value></param>
<param><key>num_inputs</key><value>4</value></param>
<param><key>num_outputs</key><value>1</value></param>
<param><key>output_index</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_inputs</key><value>4</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_4</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0</value></param>
<param><key>const</key><value>1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_1</value></param>
<param><key>const</key><value>16*5/1.</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_2</value></param>
<param><key>const</key><value>temp_atten_all_channels</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_2_0</value></param>
<param><key>const</key><value>temp_atten_all_channels</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_4</value></param>
<param><key>comment</key><value>PsDIn-sr1 = PSDout*(sr1_freq/st1_freq)</value></param>
<param><key>const</key><value>1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_4_0</value></param>
<param><key>comment</key><value>PsDIn-sr2 = PSDout*(sr2_freq/st1_freq)</value></param>
<param><key>const</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_5</value></param>
<param><key>const</key><value>0.07</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_1_0_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_1_0_0_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_1_0_0_1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_1_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_source</key>
<param><key>id</key><value>blocks_null_source_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_null_source</key>
<param><key>id</key><value>blocks_null_source_1</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_source</key>
<param><key>id</key><value>blocks_null_source_12</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_source</key>
<param><key>id</key><value>blocks_null_source_13</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_source</key>
<param><key>id</key><value>blocks_null_source_14</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_source</key>
<param><key>id</key><value>blocks_null_source_2</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_source</key>
<param><key>id</key><value>blocks_null_source_6</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_source</key>
<param><key>id</key><value>blocks_null_source_8</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_source</key>
<param><key>id</key><value>blocks_null_source_9</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_probe_rate</key>
<param><key>id</key><value>blocks_probe_rate_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>mintime</key><value>500.0</value></param>
<param><key>alpha</key><value>0.15</value></param>
</block>
<block>
<key>blocks_repeat</key>
<param><key>id</key><value>blocks_repeat_0</value></param>
<param><key>interp</key><value>int(1.2 * audio_rate / wpm)</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_vco_c</key>
<param><key>id</key><value>blocks_vco_c_0</value></param>
<param><key>amplitude</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate_sr2</value></param>
<param><key>sensitivity</key><value>2*(22/7)*(2*50e3)</value></param>
</block>
<block>
<key>blocks_vco_c</key>
<param><key>id</key><value>blocks_vco_c_0_0</value></param>
<param><key>amplitude</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate_sr2</value></param>
<param><key>sensitivity</key><value>2*(22/7)*(2*150e3)</value></param>
</block>
<block>
<key>blocks_vco_c</key>
<param><key>id</key><value>blocks_vco_c_0_0_0</value></param>
<param><key>amplitude</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate_sr2</value></param>
<param><key>sensitivity</key><value>2*(22/7)*(2*150e3)*((sr1_freq-offset_temp)/st1_freq)</value></param>
</block>
<block>
<key>blocks_vco_c</key>
<param><key>id</key><value>blocks_vco_c_0_0_0_0</value></param>
<param><key>amplitude</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samp_rate</key><value>samp_rate_sr2</value></param>
<param><key>sensitivity</key><value>2*(22/7)*(2*150e3)*((sr2_rcv_tun_freq-offset_temp)/st1_freq)</value></param>
</block>
<block>
<key>blocks_vco_c</key>
<param><key>id</key><value>blocks_vco_c_0_1</value></param>
<param><key>amplitude</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate_sr2</value></param>
<param><key>sensitivity</key><value>2*(22/7)*(2*250e3)</value></param>
</block>
<block>
<key>blocks_vco_c</key>
<param><key>id</key><value>blocks_vco_c_0_1_0</value></param>
<param><key>amplitude</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate_sr2</value></param>
<param><key>sensitivity</key><value>2*(22/7)*(2*250e3)*((sr1_freq-offset_temp)/st1_freq)</value></param>
</block>
<block>
<key>blocks_vco_c</key>
<param><key>id</key><value>blocks_vco_c_0_1_0_0</value></param>
<param><key>amplitude</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samp_rate</key><value>samp_rate_sr2</value></param>
<param><key>sensitivity</key><value>2*(22/7)*(2*250e3)*((sr2_rcv_tun_freq-offset_temp)/st1_freq)</value></param>
</block>
<block>
<key>blocks_vco_c</key>
<param><key>id</key><value>blocks_vco_c_0_2</value></param>
<param><key>amplitude</key><value>10</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samp_rate</key><value>samp_rate_sr2</value></param>
<param><key>sensitivity</key><value>2*(22/7)*(2*130e3)</value></param>
</block>
<block>
<key>blocks_vco_c</key>
<param><key>id</key><value>blocks_vco_c_0_3</value></param>
<param><key>amplitude</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate_sr2</value></param>
<param><key>sensitivity</key><value>2*(22/7)*(2*50e3)*((sr1_freq-offset_temp)/st1_freq)</value></param>
</block>
<block>
<key>blocks_vco_c</key>
<param><key>id</key><value>blocks_vco_c_0_3_0</value></param>
<param><key>amplitude</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samp_rate</key><value>samp_rate_sr2</value></param>
<param><key>sensitivity</key><value>2*(22/7)*(2*50e3)*((sr2_rcv_tun_freq-offset_temp)/st1_freq)</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vector</key><value>(1,0,1,0,1,0,1,1,1, 0,0,0,1,0,1,0,1,0,1,1,1, 0,0,0,1,0,1,0,1,0,1,1,1,0,0,0,0,0,0,0,1,1,1,0,1,0,1,0,0,0,1,0,0,0,0,0,0,0, 1,0,1,1,1,0,1,1,1,0,0,0,1,0,1,1,1,0,0,0,1,0,1,1,1,0,1,1,1,0,1,1,1,0,1,1,1,0,0,0,1,1,1,0,1,0,1,1,1,0,1,0,0,0,1,1,1,0,1,0,1,1,1,0,1,1,1,0,0,0,1,1,1,0,1,0,1,0,1,0,0,0,0,0,0,0,1,1,1,0,0,0,1,0,0,0,1,0,1,0,1,0,0,0, 1,1,1,0,0,0,1,0,1,0,0,0,1,1,1,0,1, 0,0,0,1,1,1,0,1,1,1,0,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0)</value></param>
</block>
<block>
<key>blocks_wavfile_source</key>
<param><key>id</key><value>blocks_wavfile_source_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/ray/Desktop/CQC/WA1CYB_on_Ch0.wav</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0_0</value></param>
<param><key>center_freq</key><value>offset_temp</value></param>
<param><key>decim</key><value>2</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samp_rate</key><value>samp_rate_sr1</value></param>
<param><key>taps</key><value>half_band_xlate_filter_taps_0</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>from math import sqrt</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0_2</value></param>
<param><key>cutoff_freq</key><value>3e3</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_fff</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>int(samp_rate_sr1/16)</value></param>
<param><key>width</key><value>300</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0_2_0_2_0_0</value></param>
<param><key>cutoff_freq</key><value>7500</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>int(samp_rate_sr1/16)</value></param>
<param><key>width</key><value>400</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0_2_0_2_0_0_0</value></param>
<param><key>cutoff_freq</key><value>3800*2</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>int(samp_rate_sr1/16)</value></param>
<param><key>width</key><value>800</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>note</key><value>freq. offset for DC</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>note</key><value>Recorded Msg Gen Area</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_2</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>note</key><value>Offset for DC</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_3</value></param>
<param><key>note</key><value>VVV DE WA1CYB TESTING  </value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_1</value></param>
<param><key>note</key><value>Doppler Insertion</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_10</value></param>
<param><key>note</key><value>sampling rate reduced by 4 (less UUUUs)</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_11</value></param>
<param><key>note</key><value>Bandwidth is ~62.5kHz</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_11_0</value></param>
<param><key>note</key><value>Bandwidth is ~250kHz</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_12</value></param>
<param><key>note</key><value>Shift lower 128kHz Spectrum of interest</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_12_0</value></param>
<param><key>note</key><value>Now lower 128 kHz BW</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_13</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_1_0</value></param>
<param><key>note</key><value>Doppler Insertion</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_1_3</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>note</key><value>Doppler Insertion</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_2</value></param>
<param><key>note</key><value>CW Tone at F0</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_3</value></param>
<param><key>note</key><value>Pass Timeing</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_4</value></param>
<param><key>note</key><value>If minimal Doppler.. Use This</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_4_0</value></param>
<param><key>note</key><value>nbfm Processing @-9kHz</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_5</value></param>
<param><key>comment</key><value>For Pseudo Doppler Out (PsDout):

Pseudo Doppler In 1 = PsDout*(sr1_freq/st1_freq)

PsDIn-sr1 = PSDout*(sr1_freq/st1_freq)
PsDIn-sr2= PSDout*(sr2_freq/st1_freq)</value></param>
<param><key>note</key><value>Transmit Output Doppler Switch</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_6</value></param>
<param><key>note</key><value>Reduce sensitivity here</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_6_ID_0</value></param>
<param><key>note</key><value>CW ID @-30.5kHz</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_7</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>note</key><value>Transmitter Parameters</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_8</value></param>
<param><key>note</key><value>(samp_rate_sr1/2)/4= 125kHz</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_9</value></param>
<param><key>note</key><value>Satellite Receiver #1 - SR1</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_9_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>note</key><value>Satellite Receiver #2 - SR2</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>dc_offset_mode0</key><value>2</value></param>
<param><key>corr0</key><value>sr2_ppm</value></param>
<param><key>freq0</key><value>sr2_rcv_tun_freq-sr2_freq_offset-offset_temp</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>sr2_rcv_rf_tun_gain_if</value></param>
<param><key>iq_balance_mode0</key><value>2</value></param>
<param><key>gain0</key><value>sr2_rcv_rf_tun_gain</value></param>
<param><key>comment</key><value>Valid sample rates
225,001 =&gt; 300,000   263158.001233 perferred
900,001 =&gt; 3,200,000 ( or 1,800,000 )</value></param>
<param><key>args</key><value></value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate_sr2</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>pseudo_doppler_source</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>comment</key><value>10 min pass =&gt; 600 sec
framp= 1/600</value></param>
<param><key>freq</key><value>10./600</value></param>
<param><key>offset</key><value>-.5</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>samp_rate_sr2</value></param>
<param><key>waveform</key><value>analog.GR_TRI_WAVE</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>pseudo_doppler_source_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>comment</key><value>10 min pass =&gt; 600 sec
framp= 1/600</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>freq</key><value>1./1.4</value></param>
<param><key>offset</key><value>.5</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>samp_rate_sr2</value></param>
<param><key>waveform</key><value>analog.GR_TRI_WAVE</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate_sr1/4</value></param>
<param><key>fc</key><value>sr1_freq+sr1_rit</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>2,0,1,3</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>name</key><value>"SR1 Input- Post pseudo Doppler"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymax</key><value>0</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0_0</value></param>
<param><key>bw</key><value>samp_rate_sr2</value></param>
<param><key>fc</key><value>sr2_rcv_tun_freq</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>name</key><value>"SR2 Input- Post pseudo Doppler"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymin</key><value>-100</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_1</value></param>
<param><key>bw</key><value>samp_rate_sr2</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>4,0,1,3</value></param>
<param><key>name</key><value>"All Output Post pseudo Doppler"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymax</key><value>0</value></param>
<param><key>ymin</key><value>-100</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_2</value></param>
<param><key>bw</key><value>samp_rate_sr2</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>2,3,1,1</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>name</key><value>"Applied transmitter Doppler"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymax</key><value>0</value></param>
<param><key>ymin</key><value>-100</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_2_0</value></param>
<param><key>bw</key><value>samp_rate_sr1</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>6,0,1,3</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>name</key><value>"Sat Xmtr#1 Input Spectrum"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymax</key><value>0</value></param>
<param><key>ymin</key><value>-90</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_2_0_0</value></param>
<param><key>bw</key><value>samp_rate_sr2</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>1024*4</value></param>
<param><key>gui_hint</key><value>3,0,1,3</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>label1</key><value>Channel 0</value></param>
<param><key>label2</key><value>Channel 1</value></param>
<param><key>label3</key><value>Channel 3 Linear</value></param>
<param><key>color4</key><value>"cyan"</value></param>
<param><key>label4</key><value>4 </value></param>
<param><key>color5</key><value>"black"</value></param>
<param><key>label5</key><value>5</value></param>
<param><key>width5</key><value>2</value></param>
<param><key>label6</key><value>6</value></param>
<param><key>label7</key><value>7</value></param>
<param><key>color8</key><value>"dark blue"</value></param>
<param><key>label8</key><value>8</value></param>
<param><key>name</key><value>"channel Spectrum"</value></param>
<param><key>nconnections</key><value>8</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymax</key><value>0</value></param>
<param><key>ymin</key><value>-80</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_2_0_0_0</value></param>
<param><key>bw</key><value>samp_rate_sr2</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>3,3,1,1</value></param>
<param><key>label1</key><value>11</value></param>
<param><key>label2</key><value>12</value></param>
<param><key>label3</key><value>13</value></param>
<param><key>label4</key><value>14</value></param>
<param><key>name</key><value>"channel Spectrum"</value></param>
<param><key>nconnections</key><value>4</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymax</key><value>0</value></param>
<param><key>ymin</key><value>-80</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_3_0</value></param>
<param><key>bw</key><value>samp_rate_sr1/4/2</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>label1</key><value>Test Point input</value></param>
<param><key>name</key><value>"test2"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate_sr1</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024*4</value></param>
<param><key>gui_hint</key><value>6,3,1,1</value></param>
<param><key>int_max</key><value>0</value></param>
<param><key>int_min</key><value>-50</value></param>
<param><key>name</key><value>"Output- as seen on Gnd"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0_0</value></param>
<param><key>bw</key><value>samp_rate_sr1/4</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>2,3,1,1</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>int_max</key><value>0</value></param>
<param><key>int_min</key><value>-130</value></param>
<param><key>name</key><value>"Input"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>int(samp_rate_sr1/8)</value></param>
<param><key>interp</key><value>int(samp_rate_sr1/16)</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0_0_0_0_0_0_0</value></param>
<param><key>decim</key><value>int(samp_rate_sr1/16)</value></param>
<param><key>interp</key><value>int(samp_rate_sr1)</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0_0_0_0_0_0_0_0</value></param>
<param><key>decim</key><value>int(samp_rate_sr1/4)/2</value></param>
<param><key>interp</key><value>int(samp_rate_sr1)</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_1</value></param>
<param><key>decim</key><value>2</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_2</value></param>
<param><key>decim</key><value>4</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_3</value></param>
<param><key>decim</key><value>2</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_6</value></param>
<param><key>decim</key><value>int(samp_rate_sr1/16)/5</value></param>
<param><key>interp</key><value>48000</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>root_raised_cosine_filter</key>
<param><key>id</key><value>root_raised_cosine_filter_0</value></param>
<param><key>alpha</key><value>0.35</value></param>
<param><key>type</key><value>interp_fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>ntaps</key><value>200</value></param>
<param><key>samp_rate</key><value>samp_rate_sr2</value></param>
<param><key>sym_rate</key><value>5</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>rtl_sdr_1_controls</value></param>
<param><key>gui_hint</key><value>0,2,2,1</value></param>
<param><key>label0</key><value>SR2 Receiver Frequency </value></param>
<param><key>label1</key><value>SR2 RIT</value></param>
<param><key>label2</key><value>SR2 Receiver Gain</value></param>
<param><key>label3</key><value>SR2 Receiver IF Gain</value></param>
<param><key>label4</key><value>SR2 PPM</value></param>
<param><key>label5</key><value>SR2 Squelch</value></param>
<param><key>num_tabs</key><value>6</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>sdr_sr1_controls</value></param>
<param><key>gui_hint</key><value>0,0,2,1</value></param>
<param><key>label0</key><value>SR1 Receiver Frequency</value></param>
<param><key>label1</key><value>SR1 Receiver RIT</value></param>
<param><key>label2</key><value>SR1 Receiver Gain</value></param>
<param><key>label3</key><value>SR1 Squelch</value></param>
<param><key>num_tabs</key><value>4</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>sdr_st1_controls</value></param>
<param><key>gui_hint</key><value>0,3,2,1</value></param>
<param><key>label0</key><value>ST1 Transmit Frequency</value></param>
<param><key>label1</key><value>ST1 Transmit Gain</value></param>
<param><key>label2</key><value>Pseudo Doppler</value></param>
<param><key>num_tabs</key><value>3</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>sr2_dc_iq_offset</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>freq</key><value>-offset_temp</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate_sr2</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>sr2_dc_iq_offset_0_1</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>-9e3</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate_sr1</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>sr2_dc_iq_offset_0_1_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>comment</key><value>17kHz added so the noise won't overlap the nbfm</value></param>
<param><key>freq</key><value>samp_rate_sr2/16+17e3</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate_sr2/4</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>sr2_dc_iq_offset_0_1_1</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>-samp_rate_sr1/16</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate_sr1</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>sr2_dc_iq_offset_0_2_0_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>0</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate_sr2</value></param>
<param><key>waveform</key><value>analog.GR_CONST_WAVE</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>center_freq0</key><value>st1_freq</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>20</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>comment</key><value>US Ham Band coverage

XCVR2450 2.4 GHz-4.5 GHz, 4.9-5.9 GHz
2400-2450 MHz
3300-3500 MHz
5650-5925 MHz

SBX Daughterboard 400 MHz - 4.4 GHz
420- 450 MHz
902 - 928 MHz
1240-1300 MHz
2300-2310 MHz
2390-2450 MHz
3300-3500 MHz


WiFi type Reference for Interference
902-928 MHz(NA)  (802.11ah)
2412/2462(NA)-2484 MHz
3657.5-3692.5 MHz
4910-4990 MHz (Military)
5030/5170(NA)-5835(NA)/5875 MHz
5850–5925 MHz (NA ITS)</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate_sr1</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0_0</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>center_freq0</key><value>sr1_freq+sr1_rit</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>sr1_gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>comment</key><value>Target sample rate: 0.262144 MSps
Actual sample rate: 0.263158 MSps

US Ham Band coverage

XCVR2450 2.4 GHz-4.5 GHz, 4.9-5.9 GHz
2400-2450 MHz
3300-3500 MHz
5650-5925 MHz

SBX Daughterboard 400 MHz - 4.4 GHz
420- 450 MHz
902 - 928 MHz
1240-1300 MHz
2300-2310 MHz
2390-2450 MHz
3300-3500 MHz


WiFi type Reference for Interference
902-928 MHz(NA)  (802.11ah)
2412/2462(NA)-2484 MHz
3657.5-3692.5 MHz
4910-4990 MHz (Military)
5030/5170(NA)-5835(NA)/5875 MHz
5850–5925 MHz (NA ITS)</value></param>
<param><key>dev_addr</key><value></value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>sd_spec0</key><value>A:0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate*2</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value>pc_clock</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0_0_0</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>center_freq0</key><value>sr1_freq+sr1_rit-offset_temp</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>sr1_gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>comment</key><value>Target sample rate: 0.262144 MSps
Actual sample rate: 0.263158 MSps

US Ham Band coverage

XCVR2450 2.4 GHz-4.5 GHz, 4.9-5.9 GHz
2400-2450 MHz
3300-3500 MHz
5650-5925 MHz

SBX Daughterboard 400 MHz - 4.4 GHz
420- 450 MHz
902 - 928 MHz
1240-1300 MHz
2300-2310 MHz
2390-2450 MHz
3300-3500 MHz


WiFi type Reference for Interference
902-928 MHz(NA)  (802.11ah)
2412/2462(NA)-2484 MHz
3657.5-3692.5 MHz
4910-4990 MHz (Military)
5030/5170(NA)-5835(NA)/5875 MHz
5850–5925 MHz (NA ITS)</value></param>
<param><key>dev_addr</key><value></value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>sd_spec0</key><value>A:0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate_sr1</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value>pc_clock</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0</value></param>
<param><key>stream_id</key><value>sr1_div2_rate_feed</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0</value></param>
<param><key>stream_id</key><value>sr1_div2_rate_feed</value></param>
</block>
<connection><source_block_id>analog_agc2_xx_0_0</source_block_id><sink_block_id>analog_pwr_squelch_xx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_agc2_xx_0_0_0_2</source_block_id><sink_block_id>analog_pwr_squelch_xx_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_fastnoise_source_x_1</source_block_id><sink_block_id>blocks_add_xx_4</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_nbfm_rx_2_0</source_block_id><sink_block_id>low_pass_filter_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_nbfm_rx_2_0</source_block_id><sink_block_id>rational_resampler_xxx_6</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_nbfm_tx_0_0</source_block_id><sink_block_id>low_pass_filter_0_2_0_2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_pwr_squelch_xx_0_0_0</source_block_id><sink_block_id>analog_nbfm_rx_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_pwr_squelch_xx_0_0_1</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blks2_selector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0_0</source_block_id><sink_block_id>blks2_selector_sr1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0_0_0</source_block_id><sink_block_id>blks2_selector_sr1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_1_0</source_block_id><sink_block_id>blocks_multiply_xx_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blks2_selector_0</source_block_id><sink_block_id>blocks_multiply_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_0</source_block_id><sink_block_id>qtgui_freq_sink_x_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_sr1</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_sr1_0</source_block_id><sink_block_id>blocks_multiply_xx_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_1</source_block_id><sink_block_id>blocks_multiply_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_add_xx_4</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_1</source_block_id><sink_block_id>rational_resampler_xxx_0_0_0_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_2</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_2</source_block_id><sink_block_id>rational_resampler_xxx_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_2_0</source_block_id><sink_block_id>blocks_multiply_xx_1_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_4</source_block_id><sink_block_id>blocks_vco_c_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_4</source_block_id><sink_block_id>blocks_vco_c_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_4</source_block_id><sink_block_id>blocks_vco_c_0_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_4_0</source_block_id><sink_block_id>blocks_vco_c_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_4_0</source_block_id><sink_block_id>blocks_vco_c_0_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_4_0</source_block_id><sink_block_id>blocks_vco_c_0_3_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_5</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_5</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0_0</source_block_id><sink_block_id>qtgui_freq_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0_0</source_block_id><sink_block_id>qtgui_freq_sink_x_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0_1</source_block_id><sink_block_id>blocks_multiply_const_vxx_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_1</source_block_id><sink_block_id>blocks_add_xx_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_1_0_0</source_block_id><sink_block_id>blocks_add_xx_1</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_1_0_0_0</source_block_id><sink_block_id>rational_resampler_xxx_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_1_0_0_1</source_block_id><sink_block_id>blocks_add_xx_1</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_1_1</source_block_id><sink_block_id>qtgui_freq_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_null_source_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_null_source_1</source_block_id><sink_block_id>blocks_add_xx_4</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_null_source_2</source_block_id><sink_block_id>blocks_add_xx_1</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>blocks_probe_rate_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>rate</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>blocks_repeat_0</source_block_id><sink_block_id>root_raised_cosine_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vco_c_0</source_block_id><sink_block_id>blks2_selector_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_vco_c_0_0</source_block_id><sink_block_id>blks2_selector_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_vco_c_0_0_0</source_block_id><sink_block_id>blks2_selector_sr1</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_vco_c_0_0_0_0</source_block_id><sink_block_id>blks2_selector_sr1_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_vco_c_0_1</source_block_id><sink_block_id>blks2_selector_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>blocks_vco_c_0_1_0</source_block_id><sink_block_id>blks2_selector_sr1</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>blocks_vco_c_0_1_0_0</source_block_id><sink_block_id>blks2_selector_sr1_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>blocks_vco_c_0_3</source_block_id><sink_block_id>blks2_selector_sr1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_vco_c_0_3_0</source_block_id><sink_block_id>blks2_selector_sr1_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0</source_block_id><sink_block_id>blocks_repeat_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_wavfile_source_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0_2</source_block_id><sink_block_id>analog_nbfm_tx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0_2_0_2_0_0</source_block_id><sink_block_id>rational_resampler_xxx_0_0_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>blocks_multiply_xx_0_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>pseudo_doppler_source</source_block_id><sink_block_id>blocks_multiply_const_vxx_4</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pseudo_doppler_source</source_block_id><sink_block_id>blocks_multiply_const_vxx_4_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pseudo_doppler_source</source_block_id><sink_block_id>blocks_vco_c_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pseudo_doppler_source</source_block_id><sink_block_id>blocks_vco_c_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pseudo_doppler_source</source_block_id><sink_block_id>blocks_vco_c_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pseudo_doppler_source_0</source_block_id><sink_block_id>blocks_vco_c_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>analog_agc2_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0_0_0_0_0_0_0</source_block_id><sink_block_id>blocks_multiply_xx_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0_0_0_0_0_0_0_0</source_block_id><sink_block_id>blocks_multiply_xx_1_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_1</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_2</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_2</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_2</source_block_id><sink_block_id>virtual_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_3</source_block_id><sink_block_id>analog_agc2_xx_0_0_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_3</source_block_id><sink_block_id>qtgui_freq_sink_x_3_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_6</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>root_raised_cosine_filter_0</source_block_id><sink_block_id>blocks_multiply_xx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sr2_dc_iq_offset</source_block_id><sink_block_id>blocks_multiply_xx_1_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>sr2_dc_iq_offset_0_1</source_block_id><sink_block_id>blocks_multiply_xx_1_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>sr2_dc_iq_offset_0_1_0</source_block_id><sink_block_id>blocks_multiply_xx_1_0_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>sr2_dc_iq_offset_0_1_1</source_block_id><sink_block_id>blocks_multiply_xx_1_0_0_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>sr2_dc_iq_offset_0_2_0_0</source_block_id><sink_block_id>blocks_add_xx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0_0_0</source_block_id><sink_block_id>blocks_add_xx_4</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>blocks_multiply_xx_1_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>rational_resampler_xxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
