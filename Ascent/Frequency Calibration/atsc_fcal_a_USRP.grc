<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>atsc_freq_cal</value></param>
<param><key>author</key><value>WA1CYB</value></param>
<param><key>description</key><value>Uses HD ATSC signals for a  Frequency Calibration Source</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>ATSC Frequency Calibration Source</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq_error_offset</value></param>
<param><key>value</key><value>saved_rit</value></param>
<param><key>gui_hint</key><value>2,0,1,1</value></param>
<param><key>label</key><value>"RIT (Receiver Incremental Tuning) Freq. Error Offset"</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-10000</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>10000</value></param>
<param><key>widget</key><value>counter</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>frequency_probe</value></param>
<param><key>block_id</key><value>delta_frequency</value></param>
<param><key>comment</key><value>Rcvr freq = delta_frequency =

(14-&gt;51)*6+386.309441 MHz
5 Hz sampling =&gt; 200 msec settling time for SDR</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>level_hysteresis</value></param>
<param><key>value</key><value>0.1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>level_step</value></param>
<param><key>value</key><value>1.0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>offset_tone_freq</value></param>
<param><key>value</key><value>2**16</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>ppm</value></param>
<param><key>value</key><value>saved_ppm</value></param>
<param><key>gui_hint</key><value>2,2,1,1</value></param>
<param><key>label</key><value>ppm</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-100</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>100</value></param>
<param><key>widget</key><value>counter</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rcv_rf_tun_gain</value></param>
<param><key>value</key><value>30</value></param>
<param><key>gui_hint</key><value>1,1,1,1</value></param>
<param><key>label</key><value>Receiver Gain (dB)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>45</value></param>
<param><key>widget</key><value>counter</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rcv_rf_tun_gain_if</value></param>
<param><key>value</key><value>20.0</value></param>
<param><key>gui_hint</key><value>1,2,1,1</value></param>
<param><key>label</key><value>Receiver IF Gain (dB)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0.0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>35.0</value></param>
<param><key>widget</key><value>counter</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rcv_tun_freq</value></param>
<param><key>value</key><value>rcvr_min_sweep*1e6</value></param>
<param><key>gui_hint</key><value>1,0,1,1</value></param>
<param><key>label</key><value>Manual Rcvr Frequency  (Hz) /470309441</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>40.0000e6</value></param>
<param><key>step</key><value>6.00000e6</value></param>
<param><key>stop</key><value>1.70000e9</value></param>
<param><key>widget</key><value>counter</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rcv_tun_freq_selected_1</value></param>
<param><key>comment</key><value>ch#*6+386.31 *1e6 = rcvr center freq
EX ch 47:  (47*6+386.31)*1e6= 668.31 MHz</value></param>
<param><key>value</key><value>saved_sel_1</value></param>
<param><key>gui_hint</key><value>4,0,1,1</value></param>
<param><key>label</key><value>Rcvr Cal. Freq. #1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>40.0000e6</value></param>
<param><key>step</key><value>rcvr_sweep_step*1e6</value></param>
<param><key>stop</key><value>1.70000e9</value></param>
<param><key>widget</key><value>counter</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rcv_tun_freq_selected_2</value></param>
<param><key>value</key><value>saved_sel_2</value></param>
<param><key>gui_hint</key><value>4,1,1,1</value></param>
<param><key>label</key><value>Rcvr Cal. Freq. #2</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>40.0000e6</value></param>
<param><key>step</key><value>rcvr_sweep_step*1e6</value></param>
<param><key>stop</key><value>1.70000e9</value></param>
<param><key>widget</key><value>counter</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rcv_tun_freq_selected_3</value></param>
<param><key>value</key><value>saved_sel_3</value></param>
<param><key>gui_hint</key><value>4,2,1,1</value></param>
<param><key>label</key><value>Rcvr Cal. Freq. #3</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>40.0000e6</value></param>
<param><key>step</key><value>rcvr_sweep_step*1e6</value></param>
<param><key>stop</key><value>1.70000e9</value></param>
<param><key>widget</key><value>counter</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rcv_tun_freq_selected_4</value></param>
<param><key>value</key><value>saved_sel_4</value></param>
<param><key>gui_hint</key><value>5,0,1,1</value></param>
<param><key>label</key><value>Rcvr Cal. Freq. #4</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>40.0000e6</value></param>
<param><key>step</key><value>rcvr_sweep_step*1e6</value></param>
<param><key>stop</key><value>1.70000e9</value></param>
<param><key>widget</key><value>counter</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rcv_tun_freq_selected_5</value></param>
<param><key>value</key><value>saved_sel_5</value></param>
<param><key>gui_hint</key><value>5,1,1,1</value></param>
<param><key>label</key><value>Rcvr Cal. Freq. #5</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>40.0000e6</value></param>
<param><key>step</key><value>rcvr_sweep_step*1e6</value></param>
<param><key>stop</key><value>1.70000e9</value></param>
<param><key>widget</key><value>counter</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rcv_tun_freq_selected_6</value></param>
<param><key>value</key><value>saved_sel_6</value></param>
<param><key>gui_hint</key><value>5,2,1,1</value></param>
<param><key>label</key><value>Rcvr Cal. Freq. #6</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>40.0000e6</value></param>
<param><key>step</key><value>rcvr_sweep_step*1e6</value></param>
<param><key>stop</key><value>1.70000e9</value></param>
<param><key>widget</key><value>counter</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rcvr_max_sweep</value></param>
<param><key>value</key><value>668.309441</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rcvr_min_sweep</value></param>
<param><key>value</key><value>470.309441</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rcvr_sweep_rate_init</value></param>
<param><key>value</key><value>5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rcvr_sweep_step</value></param>
<param><key>value</key><value>6.00</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>266666.000274</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_ramp</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>saved_ppm</value></param>
<param><key>config_file</key><value>atsc_config_file</value></param>
<param><key>value</key><value>0</value></param>
<param><key>option</key><value>ppm</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>ppm</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>saved_rit</value></param>
<param><key>config_file</key><value>atsc_config_file</value></param>
<param><key>value</key><value>0</value></param>
<param><key>option</key><value>freq_error_offset</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>freq_error_offset</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>saved_sel_1</value></param>
<param><key>config_file</key><value>atsc_config_file</value></param>
<param><key>value</key><value>(19*6+386.309441)*1e6</value></param>
<param><key>option</key><value>rcv_tun_freq_selected_1</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>rcv_tun_freq_selected_1</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>saved_sel_2</value></param>
<param><key>config_file</key><value>atsc_config_file</value></param>
<param><key>value</key><value>506.309441*1e6</value></param>
<param><key>option</key><value>rcv_tun_freq_selected_2</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>rcv_tun_freq_selected_2</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>saved_sel_3</value></param>
<param><key>config_file</key><value>atsc_config_file</value></param>
<param><key>value</key><value>548.309441*1e6</value></param>
<param><key>option</key><value>rcv_tun_freq_selected_3</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>rcv_tun_freq_selected_3</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>saved_sel_4</value></param>
<param><key>config_file</key><value>atsc_config_file</value></param>
<param><key>value</key><value>560.309441*1e6 </value></param>
<param><key>option</key><value>rcv_tun_freq_selected_4</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>rcv_tun_freq_selected_4</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>saved_sel_5</value></param>
<param><key>config_file</key><value>atsc_config_file</value></param>
<param><key>value</key><value>560.309441*1e6 </value></param>
<param><key>option</key><value>rcv_tun_freq_selected_5</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>rcv_tun_freq_selected_5</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>saved_sel_6</value></param>
<param><key>config_file</key><value>atsc_config_file</value></param>
<param><key>value</key><value>644.309441*1e6</value></param>
<param><key>option</key><value>rcv_tun_freq_selected_6</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>rcv_tun_freq_selected_6</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>selected_enable</value></param>
<param><key>block_id</key><value>delta_frequency_selected</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>5</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>sweep_enable</value></param>
<param><key>value</key><value>1</value></param>
<param><key>gui_hint</key><value>2,1,1,1</value></param>
<param><key>label0</key><value>Single Frequency (Channel)</value></param>
<param><key>label1</key><value>My 6 selected frequencies</value></param>
<param><key>label2</key><value>Ramp: Channels 14-&gt;51</value></param>
<param><key>label</key><value>Mode Switch</value></param>
<param><key>num_opts</key><value>3</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>option1</key><value>1</value></param>
<param><key>option2</key><value>2</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0</value></param>
<param><key>const</key><value>rcv_tun_freq_selected_1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0_0</value></param>
<param><key>const</key><value>rcv_tun_freq_selected_2</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0_0_0</value></param>
<param><key>const</key><value>rcv_tun_freq_selected_4</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0_0_1</value></param>
<param><key>const</key><value>rcv_tun_freq_selected_6</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0_1</value></param>
<param><key>const</key><value>rcv_tun_freq_selected_3</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0_2</value></param>
<param><key>const</key><value>rcv_tun_freq_selected_5</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_1</value></param>
<param><key>const</key><value>frequency_probe</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_1_0</value></param>
<param><key>const</key><value>14*6.0000</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>51.0-14.0</value></param>
<param><key>comment</key><value>Examples:

freq= 1/1000 =&gt; 10 seconds
 1/100 =&gt; 1 sec
1/(51.0-14.0)*10 =&gt; 3.7 seconds
      1/3700 =&gt; 37 seconds
1/10000 =&gt; 100 seconds</value></param>
<param><key>freq</key><value>1/3700.0</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>samp_rate_ramp</value></param>
<param><key>waveform</key><value>analog.GR_SAW_WAVE</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0_0</value></param>
<param><key>amp</key><value>6.0</value></param>
<param><key>comment</key><value>Examples:

freq= 1/1000 =&gt; 10 seconds
 1/100 =&gt; 1 sec
1/(51.0-14.0)*10 =&gt; 3.7 seconds
      1/3700 =&gt; 37 seconds
1/10000 =&gt; 100 seconds</value></param>
<param><key>freq</key><value>1/2000.0</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>samp_rate_ramp</value></param>
<param><key>waveform</key><value>analog.GR_SAW_WAVE</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_1</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>offset_tone_freq</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_1_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>freq_error_offset</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>blks2_selector_0</value></param>
<param><key>input_index</key><value>sweep_enable</value></param>
<param><key>num_inputs</key><value>3</value></param>
<param><key>num_outputs</key><value>1</value></param>
<param><key>output_index</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>blks2_selector_0_0</value></param>
<param><key>input_index</key><value>selected_enable</value></param>
<param><key>num_inputs</key><value>6</value></param>
<param><key>num_outputs</key><value>1</value></param>
<param><key>output_index</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blocks_add_const_vxx</key>
<param><key>id</key><value>blocks_add_const_vxx_0</value></param>
<param><key>const</key><value>386.309441</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_add_const_vxx</key>
<param><key>id</key><value>blocks_add_const_vxx_0_0</value></param>
<param><key>const</key><value>-386.309441*1e6</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_add_const_vxx</key>
<param><key>id</key><value>blocks_add_const_vxx_1</value></param>
<param><key>const</key><value>14</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_inputs</key><value>4</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_inputs</key><value>10</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_1_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_inputs</key><value>10</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_1_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_inputs</key><value>10</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_1_2</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_inputs</key><value>10</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_1_3</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_inputs</key><value>6</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>1/6.0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0</value></param>
<param><key>const</key><value>level_step</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0_0</value></param>
<param><key>const</key><value>level_step</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0_0_0</value></param>
<param><key>const</key><value>level_step</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0_0_0_0</value></param>
<param><key>const</key><value>level_step</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0_0_0_1</value></param>
<param><key>const</key><value>level_step</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0_0_0_2</value></param>
<param><key>const</key><value>level_step</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0_0_0_3</value></param>
<param><key>const</key><value>level_step</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0_0_1</value></param>
<param><key>const</key><value>level_step</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0_0_2</value></param>
<param><key>const</key><value>level_step</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0_0_3</value></param>
<param><key>const</key><value>level_step</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0_0_4</value></param>
<param><key>const</key><value>1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0_1</value></param>
<param><key>const</key><value>level_step</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0_1_0</value></param>
<param><key>const</key><value>level_step</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0_1_0_0</value></param>
<param><key>const</key><value>level_step</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0_1_0_1</value></param>
<param><key>const</key><value>level_step</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0_1_0_2</value></param>
<param><key>const</key><value>level_step</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0_1_1</value></param>
<param><key>const</key><value>level_step</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0_1_2</value></param>
<param><key>const</key><value>level_step</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0_1_3</value></param>
<param><key>const</key><value>level_step</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0_2</value></param>
<param><key>const</key><value>level_step</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0_3</value></param>
<param><key>const</key><value>level_step</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0_4</value></param>
<param><key>const</key><value>level_step</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0_5</value></param>
<param><key>const</key><value>level_step</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_1</value></param>
<param><key>const</key><value>level_step</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_1_0</value></param>
<param><key>const</key><value>level_step</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_1_0_0</value></param>
<param><key>const</key><value>level_step</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_1_0_1</value></param>
<param><key>const</key><value>level_step</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_1_0_2</value></param>
<param><key>const</key><value>level_step</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_1_0_3</value></param>
<param><key>const</key><value>level_step</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_1_1</value></param>
<param><key>const</key><value>level_step</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_1_1_0</value></param>
<param><key>const</key><value>level_step</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_1_1_1</value></param>
<param><key>const</key><value>level_step</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_1_2</value></param>
<param><key>const</key><value>level_step</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_1_3</value></param>
<param><key>const</key><value>level_step</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_1_4</value></param>
<param><key>const</key><value>level_step</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_2</value></param>
<param><key>const</key><value>level_step</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_2_0</value></param>
<param><key>const</key><value>level_step</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_2_0_0</value></param>
<param><key>const</key><value>level_step</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_2_0_1</value></param>
<param><key>const</key><value>level_step</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_2_0_2</value></param>
<param><key>const</key><value>level_step</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_2_1</value></param>
<param><key>const</key><value>level_step</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_2_2</value></param>
<param><key>const</key><value>level_step</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_2_3</value></param>
<param><key>const</key><value>level_step</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_3</value></param>
<param><key>const</key><value>level_step</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_4</value></param>
<param><key>const</key><value>level_step</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_5</value></param>
<param><key>const</key><value>level_step</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_6</value></param>
<param><key>const</key><value>1.0/6.0e6</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1</value></param>
<param><key>const</key><value>1.0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1_0</value></param>
<param><key>const</key><value>1.0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1_1</value></param>
<param><key>const</key><value>1.0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1_2</value></param>
<param><key>const</key><value>1.0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1_3</value></param>
<param><key>const</key><value>1.0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_2</value></param>
<param><key>const</key><value>1.0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_3</value></param>
<param><key>const</key><value>6.0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_4</value></param>
<param><key>const</key><value>6.0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_threshold_ff</key>
<param><key>id</key><value>blocks_threshold_ff_0</value></param>
<param><key>high</key><value>37*level_step+level_hysteresis</value></param>
<param><key>init</key><value>0</value></param>
<param><key>low</key><value>37*level_step</value></param>
</block>
<block>
<key>blocks_threshold_ff</key>
<param><key>id</key><value>blocks_threshold_ff_0_0</value></param>
<param><key>high</key><value>38*level_step+level_hysteresis</value></param>
<param><key>init</key><value>0</value></param>
<param><key>low</key><value>38*level_step</value></param>
</block>
<block>
<key>blocks_threshold_ff</key>
<param><key>id</key><value>blocks_threshold_ff_0_0_0</value></param>
<param><key>high</key><value>40*level_step+level_hysteresis</value></param>
<param><key>init</key><value>0</value></param>
<param><key>low</key><value>40*level_step</value></param>
</block>
<block>
<key>blocks_threshold_ff</key>
<param><key>id</key><value>blocks_threshold_ff_0_0_0_0</value></param>
<param><key>high</key><value>36*level_step+level_hysteresis</value></param>
<param><key>init</key><value>0</value></param>
<param><key>low</key><value>36*level_step</value></param>
</block>
<block>
<key>blocks_threshold_ff</key>
<param><key>id</key><value>blocks_threshold_ff_0_0_0_0_0</value></param>
<param><key>high</key><value>26*level_step+level_hysteresis</value></param>
<param><key>init</key><value>0</value></param>
<param><key>low</key><value>26*level_step</value></param>
</block>
<block>
<key>blocks_threshold_ff</key>
<param><key>id</key><value>blocks_threshold_ff_0_0_0_0_1</value></param>
<param><key>high</key><value>16*level_step+level_hysteresis</value></param>
<param><key>init</key><value>0</value></param>
<param><key>low</key><value>16*level_step</value></param>
</block>
<block>
<key>blocks_threshold_ff</key>
<param><key>id</key><value>blocks_threshold_ff_0_0_0_0_2</value></param>
<param><key>high</key><value>6*level_step+level_hysteresis</value></param>
<param><key>init</key><value>0</value></param>
<param><key>low</key><value>6*level_step</value></param>
</block>
<block>
<key>blocks_threshold_ff</key>
<param><key>id</key><value>blocks_threshold_ff_0_0_0_0_3</value></param>
<param><key>high</key><value>2*level_step+level_hysteresis</value></param>
<param><key>init</key><value>0</value></param>
<param><key>low</key><value>2*level_step</value></param>
</block>
<block>
<key>blocks_threshold_ff</key>
<param><key>id</key><value>blocks_threshold_ff_0_0_0_1</value></param>
<param><key>high</key><value>30*level_step+level_hysteresis</value></param>
<param><key>init</key><value>0</value></param>
<param><key>low</key><value>30*level_step</value></param>
</block>
<block>
<key>blocks_threshold_ff</key>
<param><key>id</key><value>blocks_threshold_ff_0_0_0_2</value></param>
<param><key>high</key><value>20*level_step+level_hysteresis</value></param>
<param><key>init</key><value>0</value></param>
<param><key>low</key><value>20*level_step</value></param>
</block>
<block>
<key>blocks_threshold_ff</key>
<param><key>id</key><value>blocks_threshold_ff_0_0_0_3</value></param>
<param><key>high</key><value>10*level_step+level_hysteresis</value></param>
<param><key>init</key><value>0</value></param>
<param><key>low</key><value>10*level_step</value></param>
</block>
<block>
<key>blocks_threshold_ff</key>
<param><key>id</key><value>blocks_threshold_ff_0_0_0_4</value></param>
<param><key>high</key><value>6*level_step-1e-3</value></param>
<param><key>init</key><value>0</value></param>
<param><key>low</key><value>6*level_step-level_hysteresis-1e-3</value></param>
</block>
<block>
<key>blocks_threshold_ff</key>
<param><key>id</key><value>blocks_threshold_ff_0_0_1</value></param>
<param><key>high</key><value>34*level_step+level_hysteresis</value></param>
<param><key>init</key><value>0</value></param>
<param><key>low</key><value>34*level_step</value></param>
</block>
<block>
<key>blocks_threshold_ff</key>
<param><key>id</key><value>blocks_threshold_ff_0_0_1_0</value></param>
<param><key>high</key><value>32*level_step+level_hysteresis</value></param>
<param><key>init</key><value>0</value></param>
<param><key>low</key><value>32*level_step</value></param>
</block>
<block>
<key>blocks_threshold_ff</key>
<param><key>id</key><value>blocks_threshold_ff_0_0_1_0_0</value></param>
<param><key>high</key><value>22*level_step+level_hysteresis</value></param>
<param><key>init</key><value>0</value></param>
<param><key>low</key><value>22*level_step</value></param>
</block>
<block>
<key>blocks_threshold_ff</key>
<param><key>id</key><value>blocks_threshold_ff_0_0_1_0_1</value></param>
<param><key>high</key><value>12*level_step+level_hysteresis</value></param>
<param><key>init</key><value>0</value></param>
<param><key>low</key><value>12*level_step</value></param>
</block>
<block>
<key>blocks_threshold_ff</key>
<param><key>id</key><value>blocks_threshold_ff_0_0_1_0_2</value></param>
<param><key>high</key><value>2*level_step+level_hysteresis</value></param>
<param><key>init</key><value>0</value></param>
<param><key>low</key><value>2*level_step</value></param>
</block>
<block>
<key>blocks_threshold_ff</key>
<param><key>id</key><value>blocks_threshold_ff_0_0_1_1</value></param>
<param><key>high</key><value>24*level_step+level_hysteresis</value></param>
<param><key>init</key><value>0</value></param>
<param><key>low</key><value>24*level_step</value></param>
</block>
<block>
<key>blocks_threshold_ff</key>
<param><key>id</key><value>blocks_threshold_ff_0_0_1_2</value></param>
<param><key>high</key><value>14*level_step+level_hysteresis</value></param>
<param><key>init</key><value>0</value></param>
<param><key>low</key><value>14*level_step</value></param>
</block>
<block>
<key>blocks_threshold_ff</key>
<param><key>id</key><value>blocks_threshold_ff_0_0_1_3</value></param>
<param><key>high</key><value>4*level_step+level_hysteresis</value></param>
<param><key>init</key><value>0</value></param>
<param><key>low</key><value>4*level_step</value></param>
</block>
<block>
<key>blocks_threshold_ff</key>
<param><key>id</key><value>blocks_threshold_ff_0_0_2</value></param>
<param><key>high</key><value>28*level_step+level_hysteresis</value></param>
<param><key>init</key><value>0</value></param>
<param><key>low</key><value>28*level_step</value></param>
</block>
<block>
<key>blocks_threshold_ff</key>
<param><key>id</key><value>blocks_threshold_ff_0_0_3</value></param>
<param><key>high</key><value>18*level_step+level_hysteresis</value></param>
<param><key>init</key><value>0</value></param>
<param><key>low</key><value>18*level_step</value></param>
</block>
<block>
<key>blocks_threshold_ff</key>
<param><key>id</key><value>blocks_threshold_ff_0_0_4</value></param>
<param><key>high</key><value>8*level_step+level_hysteresis</value></param>
<param><key>init</key><value>0</value></param>
<param><key>low</key><value>8*level_step</value></param>
</block>
<block>
<key>blocks_threshold_ff</key>
<param><key>id</key><value>blocks_threshold_ff_0_0_5</value></param>
<param><key>high</key><value>4*level_step+level_hysteresis</value></param>
<param><key>init</key><value>0</value></param>
<param><key>low</key><value>4*level_step</value></param>
</block>
<block>
<key>blocks_threshold_ff</key>
<param><key>id</key><value>blocks_threshold_ff_0_1</value></param>
<param><key>high</key><value>39*level_step+level_hysteresis</value></param>
<param><key>init</key><value>0</value></param>
<param><key>low</key><value>39*level_step</value></param>
</block>
<block>
<key>blocks_threshold_ff</key>
<param><key>id</key><value>blocks_threshold_ff_0_1_0</value></param>
<param><key>high</key><value>35*level_step+level_hysteresis</value></param>
<param><key>init</key><value>0</value></param>
<param><key>low</key><value>35*level_step</value></param>
</block>
<block>
<key>blocks_threshold_ff</key>
<param><key>id</key><value>blocks_threshold_ff_0_1_0_0</value></param>
<param><key>high</key><value>25*level_step+level_hysteresis</value></param>
<param><key>init</key><value>0</value></param>
<param><key>low</key><value>25*level_step</value></param>
</block>
<block>
<key>blocks_threshold_ff</key>
<param><key>id</key><value>blocks_threshold_ff_0_1_0_1</value></param>
<param><key>high</key><value>15*level_step+level_hysteresis</value></param>
<param><key>init</key><value>0</value></param>
<param><key>low</key><value>15*level_step</value></param>
</block>
<block>
<key>blocks_threshold_ff</key>
<param><key>id</key><value>blocks_threshold_ff_0_1_0_2</value></param>
<param><key>high</key><value>5*level_step+level_hysteresis</value></param>
<param><key>init</key><value>0</value></param>
<param><key>low</key><value>5*level_step</value></param>
</block>
<block>
<key>blocks_threshold_ff</key>
<param><key>id</key><value>blocks_threshold_ff_0_1_0_3</value></param>
<param><key>high</key><value>1*level_step+level_hysteresis</value></param>
<param><key>init</key><value>0</value></param>
<param><key>low</key><value>1*level_step</value></param>
</block>
<block>
<key>blocks_threshold_ff</key>
<param><key>id</key><value>blocks_threshold_ff_0_1_1</value></param>
<param><key>high</key><value>29*level_step+level_hysteresis</value></param>
<param><key>init</key><value>0</value></param>
<param><key>low</key><value>29*level_step</value></param>
</block>
<block>
<key>blocks_threshold_ff</key>
<param><key>id</key><value>blocks_threshold_ff_0_1_2</value></param>
<param><key>high</key><value>19*level_step+level_hysteresis</value></param>
<param><key>init</key><value>0</value></param>
<param><key>low</key><value>19*level_step</value></param>
</block>
<block>
<key>blocks_threshold_ff</key>
<param><key>id</key><value>blocks_threshold_ff_0_1_3</value></param>
<param><key>high</key><value>9*level_step+level_hysteresis</value></param>
<param><key>init</key><value>0</value></param>
<param><key>low</key><value>9*level_step</value></param>
</block>
<block>
<key>blocks_threshold_ff</key>
<param><key>id</key><value>blocks_threshold_ff_0_1_4</value></param>
<param><key>high</key><value>5*level_step+level_hysteresis</value></param>
<param><key>init</key><value>0</value></param>
<param><key>low</key><value>5*level_step</value></param>
</block>
<block>
<key>blocks_threshold_ff</key>
<param><key>id</key><value>blocks_threshold_ff_0_2</value></param>
<param><key>high</key><value>33*level_step+level_hysteresis</value></param>
<param><key>init</key><value>0</value></param>
<param><key>low</key><value>33*level_step</value></param>
</block>
<block>
<key>blocks_threshold_ff</key>
<param><key>id</key><value>blocks_threshold_ff_0_2_0</value></param>
<param><key>high</key><value>31*level_step+level_hysteresis</value></param>
<param><key>init</key><value>0</value></param>
<param><key>low</key><value>31*level_step</value></param>
</block>
<block>
<key>blocks_threshold_ff</key>
<param><key>id</key><value>blocks_threshold_ff_0_2_0_0</value></param>
<param><key>high</key><value>21*level_step+level_hysteresis</value></param>
<param><key>init</key><value>0</value></param>
<param><key>low</key><value>21*level_step</value></param>
</block>
<block>
<key>blocks_threshold_ff</key>
<param><key>id</key><value>blocks_threshold_ff_0_2_0_1</value></param>
<param><key>high</key><value>11*level_step+level_hysteresis</value></param>
<param><key>init</key><value>0</value></param>
<param><key>low</key><value>11*level_step</value></param>
</block>
<block>
<key>blocks_threshold_ff</key>
<param><key>id</key><value>blocks_threshold_ff_0_2_0_2</value></param>
<param><key>high</key><value>1*level_step+level_hysteresis</value></param>
<param><key>init</key><value>0</value></param>
<param><key>low</key><value>1*level_step</value></param>
</block>
<block>
<key>blocks_threshold_ff</key>
<param><key>id</key><value>blocks_threshold_ff_0_2_1</value></param>
<param><key>high</key><value>23*level_step+level_hysteresis</value></param>
<param><key>init</key><value>0</value></param>
<param><key>low</key><value>23*level_step</value></param>
</block>
<block>
<key>blocks_threshold_ff</key>
<param><key>id</key><value>blocks_threshold_ff_0_2_2</value></param>
<param><key>high</key><value>13*level_step+level_hysteresis</value></param>
<param><key>init</key><value>0</value></param>
<param><key>low</key><value>13*level_step</value></param>
</block>
<block>
<key>blocks_threshold_ff</key>
<param><key>id</key><value>blocks_threshold_ff_0_2_3</value></param>
<param><key>high</key><value>3*level_step+level_hysteresis</value></param>
<param><key>init</key><value>0</value></param>
<param><key>low</key><value>3*level_step</value></param>
</block>
<block>
<key>blocks_threshold_ff</key>
<param><key>id</key><value>blocks_threshold_ff_0_3</value></param>
<param><key>high</key><value>27*level_step+level_hysteresis</value></param>
<param><key>init</key><value>0</value></param>
<param><key>low</key><value>27*level_step</value></param>
</block>
<block>
<key>blocks_threshold_ff</key>
<param><key>id</key><value>blocks_threshold_ff_0_4</value></param>
<param><key>high</key><value>17*level_step+level_hysteresis</value></param>
<param><key>init</key><value>0</value></param>
<param><key>low</key><value>17*level_step</value></param>
</block>
<block>
<key>blocks_threshold_ff</key>
<param><key>id</key><value>blocks_threshold_ff_0_5</value></param>
<param><key>high</key><value>7*level_step+level_hysteresis</value></param>
<param><key>init</key><value>0</value></param>
<param><key>low</key><value>7*level_step</value></param>
</block>
<block>
<key>blocks_threshold_ff</key>
<param><key>id</key><value>blocks_threshold_ff_0_6</value></param>
<param><key>high</key><value>3*level_step+level_hysteresis</value></param>
<param><key>init</key><value>0</value></param>
<param><key>low</key><value>3*level_step</value></param>
</block>
<block>
<key>blocks_probe_signal_x</key>
<param><key>id</key><value>delta_frequency</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_probe_signal_x</key>
<param><key>id</key><value>delta_frequency_selected</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>cutoff_freq</key><value>20e3</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>1e3</value></param>
<param><key>win</key><value>firdes.WIN_BLACKMAN</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>note</key><value>Real Time Freq</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_0</value></param>
<param><key>note</key><value>A/D converter with hysteresis 0-&gt;40 volts</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_0_0</value></param>
<param><key>note</key><value>A/D converter with hysteresis 0-&gt;6volts</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_1</value></param>
<param><key>note</key><value>Ramp feed thresholds</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_1</value></param>
<param><key>note</key><value>Threshold+14=ch #</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_1_0</value></param>
<param><key>note</key><value>thresholds output 0 through 5 and repaets</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_2</value></param>
<param><key>note</key><value>output to probe, </value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_3</value></param>
<param><key>note</key><value>selected_enable to selector</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_4</value></param>
<param><key>note</key><value>DC and quadrature shift</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_5</value></param>
<param><key>note</key><value>USRP is assumed to be a N-210 model</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>corr0</key><value>ppm</value></param>
<param><key>freq0</key><value>rcv_tun_freq+(frequency_probe-84.0)*1e6+offset_tone_freq</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>rcv_rf_tun_gain_if</value></param>
<param><key>gain0</key><value>rcv_rf_tun_gain</value></param>
<param><key>args</key><value></value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>266666.000274</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_1</value></param>
<param><key>bw</key><value>samp_rate/100</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024*2</value></param>
<param><key>gui_hint</key><value>0,1,1,2</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>label1</key><value>Frequency Error</value></param>
<param><key>name</key><value>"Zoom x100"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymax</key><value>-20</value></param>
<param><key>ymin</key><value>-120</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0</value></param>
<param><key>gui_hint</key><value>3,1,1,2</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_HORIZ</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label1</key><value>Jump Frequency</value></param>
<param><key>unit1</key><value>MHz</value></param>
<param><key>max</key><value>700</value></param>
<param><key>min</key><value>350</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0_1</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>gui_hint</key><value>3,0,1,1</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_NONE</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label1</key><value>FCC Channel Number</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_7</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_NONE</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label1</key><value>analog output</value></param>
<param><key>max</key><value>100</value></param>
<param><key>min</key><value>-100</value></param>
<param><key>name</key><value>"new sink"</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_7_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_NONE</value></param>
<param><key>type</key><value>float</value></param>
<param><key>max</key><value>55</value></param>
<param><key>min</key><value>0</value></param>
<param><key>name</key><value>"Selected Channel"</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate/10.0</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>fftsize</key><value>1024*4</value></param>
<param><key>gui_hint</key><value>0,0,1,1</value></param>
<param><key>name</key><value>"Input Spectrum - Freq. Error"</value></param>
<param><key>plotconst</key><value>False</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>showrf</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>100</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_1</value></param>
<param><key>decim</key><value>10</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>center_freq0</key><value>rcv_tun_freq+(frequency_probe-84.0)*1e6+offset_tone_freq</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>rcv_rf_tun_gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>comment</key><value>Target sample rate: 0.266666 MSps
 Actual sample rate: 0.265957 MSps

US Ham Band coverage

XCVR2450 2.4 GHz-4.5 GHz, 4.9-5.9 GHz
2400-2450 MHz
3300-3500 MHz
5650-5925 MHz

SBX Daughterboard 400 MHz - 4.4 GHz
420- 450 MHz
902 - 928 MHz
1240-1300 MHz
2300-2310 MHz
2390-2450 MHz
3300-3500 MHz


WiFi type Reference for Interference
902-928 MHz(NA)  (802.11ah)
2412/2462(NA)-2484 MHz
3657.5-3692.5 MHz
4910-4990 MHz (Military)
5030/5170(NA)-5835(NA)/5875 MHz
5850–5925 MHz (NA ITS)</value></param>
<param><key>dev_addr</key><value></value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>sd_spec0</key><value>A:0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value>pc_clock</value></param>
</block>
<connection><source_block_id>analog_const_source_x_0</source_block_id><sink_block_id>blks2_selector_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_const_source_x_0_0</source_block_id><sink_block_id>blks2_selector_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_const_source_x_0_0_0</source_block_id><sink_block_id>blks2_selector_0_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>analog_const_source_x_0_0_1</source_block_id><sink_block_id>blks2_selector_0_0</sink_block_id><source_key>0</source_key><sink_key>5</sink_key></connection>
<connection><source_block_id>analog_const_source_x_0_1</source_block_id><sink_block_id>blks2_selector_0_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>analog_const_source_x_0_2</source_block_id><sink_block_id>blks2_selector_0_0</sink_block_id><source_key>0</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>analog_const_source_x_1</source_block_id><sink_block_id>blocks_add_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_const_source_x_1_0</source_block_id><sink_block_id>blks2_selector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_1_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_1_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_1_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_1</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_1_0</source_block_id><sink_block_id>blocks_multiply_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blks2_selector_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_0</source_block_id><sink_block_id>delta_frequency</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_0_0</source_block_id><sink_block_id>blocks_add_const_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_const_vxx_0</source_block_id><sink_block_id>qtgui_number_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_const_vxx_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_6</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_const_vxx_1</source_block_id><sink_block_id>blocks_multiply_const_vxx_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_1</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_1_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_add_xx_1_1</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_add_xx_1_2</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>blocks_add_xx_1_3</source_block_id><sink_block_id>delta_frequency_selected</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_1_3</source_block_id><sink_block_id>qtgui_number_sink_7</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>qtgui_number_sink_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>blocks_add_xx_1</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_0</source_block_id><sink_block_id>blocks_add_xx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_0_0</source_block_id><sink_block_id>blocks_add_xx_1</sink_block_id><source_key>0</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_0_0_0</source_block_id><sink_block_id>blocks_add_xx_1_0</sink_block_id><source_key>0</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_0_0_1</source_block_id><sink_block_id>blocks_add_xx_1_1</sink_block_id><source_key>0</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_0_0_2</source_block_id><sink_block_id>blocks_add_xx_1_2</sink_block_id><source_key>0</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_0_0_3</source_block_id><sink_block_id>blocks_add_xx_1_3</sink_block_id><source_key>0</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_0_1</source_block_id><sink_block_id>blocks_add_xx_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_0_2</source_block_id><sink_block_id>blocks_add_xx_1_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_0_3</source_block_id><sink_block_id>blocks_add_xx_1_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_0_4</source_block_id><sink_block_id>blocks_add_xx_1_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_1</source_block_id><sink_block_id>blocks_add_xx_1</sink_block_id><source_key>0</source_key><sink_key>6</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_1_0</source_block_id><sink_block_id>blocks_add_xx_1</sink_block_id><source_key>0</source_key><sink_key>8</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_1_0_0</source_block_id><sink_block_id>blocks_add_xx_1_0</sink_block_id><source_key>0</source_key><sink_key>8</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_1_0_1</source_block_id><sink_block_id>blocks_add_xx_1_1</sink_block_id><source_key>0</source_key><sink_key>8</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_1_0_2</source_block_id><sink_block_id>blocks_add_xx_1_2</sink_block_id><source_key>0</source_key><sink_key>8</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_1_1</source_block_id><sink_block_id>blocks_add_xx_1_0</sink_block_id><source_key>0</source_key><sink_key>6</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_1_2</source_block_id><sink_block_id>blocks_add_xx_1_1</sink_block_id><source_key>0</source_key><sink_key>6</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_1_3</source_block_id><sink_block_id>blocks_add_xx_1_2</sink_block_id><source_key>0</source_key><sink_key>6</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_2</source_block_id><sink_block_id>blocks_add_xx_1_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_3</source_block_id><sink_block_id>blocks_add_xx_1_1</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_4</source_block_id><sink_block_id>blocks_add_xx_1_2</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_5</source_block_id><sink_block_id>blocks_add_xx_1_3</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_1</source_block_id><sink_block_id>blocks_add_xx_1</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_1_0</source_block_id><sink_block_id>blocks_add_xx_1</sink_block_id><source_key>0</source_key><sink_key>5</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_1_0_0</source_block_id><sink_block_id>blocks_add_xx_1_0</sink_block_id><source_key>0</source_key><sink_key>5</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_1_0_1</source_block_id><sink_block_id>blocks_add_xx_1_1</sink_block_id><source_key>0</source_key><sink_key>5</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_1_0_2</source_block_id><sink_block_id>blocks_add_xx_1_2</sink_block_id><source_key>0</source_key><sink_key>5</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_1_0_3</source_block_id><sink_block_id>blocks_add_xx_1_3</sink_block_id><source_key>0</source_key><sink_key>5</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_1_1</source_block_id><sink_block_id>blocks_add_xx_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_1_1_0</source_block_id><sink_block_id>blocks_add_xx_1_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_1_1_1</source_block_id><sink_block_id>blocks_add_xx_1_3</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_1_2</source_block_id><sink_block_id>blocks_add_xx_1_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_1_3</source_block_id><sink_block_id>blocks_add_xx_1_2</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_1_4</source_block_id><sink_block_id>blocks_add_xx_1_3</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_2</source_block_id><sink_block_id>blocks_add_xx_1</sink_block_id><source_key>0</source_key><sink_key>7</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_2_0</source_block_id><sink_block_id>blocks_add_xx_1</sink_block_id><source_key>0</source_key><sink_key>9</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_2_0_0</source_block_id><sink_block_id>blocks_add_xx_1_0</sink_block_id><source_key>0</source_key><sink_key>9</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_2_0_1</source_block_id><sink_block_id>blocks_add_xx_1_1</sink_block_id><source_key>0</source_key><sink_key>9</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_2_0_2</source_block_id><sink_block_id>blocks_add_xx_1_2</sink_block_id><source_key>0</source_key><sink_key>9</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_2_1</source_block_id><sink_block_id>blocks_add_xx_1_0</sink_block_id><source_key>0</source_key><sink_key>7</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_2_2</source_block_id><sink_block_id>blocks_add_xx_1_1</sink_block_id><source_key>0</source_key><sink_key>7</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_2_3</source_block_id><sink_block_id>blocks_add_xx_1_2</sink_block_id><source_key>0</source_key><sink_key>7</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_3</source_block_id><sink_block_id>blocks_add_xx_1_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_4</source_block_id><sink_block_id>blocks_add_xx_1_1</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_5</source_block_id><sink_block_id>blocks_add_xx_1_2</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_6</source_block_id><sink_block_id>blocks_multiply_const_vxx_4</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_6</source_block_id><sink_block_id>qtgui_number_sink_7_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1</source_block_id><sink_block_id>blocks_threshold_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1</source_block_id><sink_block_id>blocks_threshold_ff_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1</source_block_id><sink_block_id>blocks_threshold_ff_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1</source_block_id><sink_block_id>blocks_threshold_ff_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1</source_block_id><sink_block_id>blocks_threshold_ff_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1</source_block_id><sink_block_id>blocks_threshold_ff_0_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1</source_block_id><sink_block_id>blocks_threshold_ff_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1</source_block_id><sink_block_id>blocks_threshold_ff_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1</source_block_id><sink_block_id>blocks_threshold_ff_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1</source_block_id><sink_block_id>blocks_threshold_ff_0_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1_0</source_block_id><sink_block_id>blocks_threshold_ff_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1_0</source_block_id><sink_block_id>blocks_threshold_ff_0_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1_0</source_block_id><sink_block_id>blocks_threshold_ff_0_0_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1_0</source_block_id><sink_block_id>blocks_threshold_ff_0_0_1_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1_0</source_block_id><sink_block_id>blocks_threshold_ff_0_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1_0</source_block_id><sink_block_id>blocks_threshold_ff_0_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1_0</source_block_id><sink_block_id>blocks_threshold_ff_0_1_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1_0</source_block_id><sink_block_id>blocks_threshold_ff_0_2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1_0</source_block_id><sink_block_id>blocks_threshold_ff_0_2_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1_0</source_block_id><sink_block_id>blocks_threshold_ff_0_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1_1</source_block_id><sink_block_id>blocks_threshold_ff_0_0_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1_1</source_block_id><sink_block_id>blocks_threshold_ff_0_0_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1_1</source_block_id><sink_block_id>blocks_threshold_ff_0_0_1_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1_1</source_block_id><sink_block_id>blocks_threshold_ff_0_0_1_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1_1</source_block_id><sink_block_id>blocks_threshold_ff_0_0_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1_1</source_block_id><sink_block_id>blocks_threshold_ff_0_1_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1_1</source_block_id><sink_block_id>blocks_threshold_ff_0_1_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1_1</source_block_id><sink_block_id>blocks_threshold_ff_0_2_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1_1</source_block_id><sink_block_id>blocks_threshold_ff_0_2_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1_1</source_block_id><sink_block_id>blocks_threshold_ff_0_4</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1_2</source_block_id><sink_block_id>blocks_threshold_ff_0_0_0_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1_2</source_block_id><sink_block_id>blocks_threshold_ff_0_0_0_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1_2</source_block_id><sink_block_id>blocks_threshold_ff_0_0_1_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1_2</source_block_id><sink_block_id>blocks_threshold_ff_0_0_1_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1_2</source_block_id><sink_block_id>blocks_threshold_ff_0_0_4</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1_2</source_block_id><sink_block_id>blocks_threshold_ff_0_1_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1_2</source_block_id><sink_block_id>blocks_threshold_ff_0_1_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1_2</source_block_id><sink_block_id>blocks_threshold_ff_0_2_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1_2</source_block_id><sink_block_id>blocks_threshold_ff_0_2_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1_2</source_block_id><sink_block_id>blocks_threshold_ff_0_5</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1_3</source_block_id><sink_block_id>blocks_threshold_ff_0_0_0_0_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1_3</source_block_id><sink_block_id>blocks_threshold_ff_0_0_0_4</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1_3</source_block_id><sink_block_id>blocks_threshold_ff_0_0_5</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1_3</source_block_id><sink_block_id>blocks_threshold_ff_0_1_0_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1_3</source_block_id><sink_block_id>blocks_threshold_ff_0_1_4</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1_3</source_block_id><sink_block_id>blocks_threshold_ff_0_6</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_2</source_block_id><sink_block_id>blocks_add_const_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_3</source_block_id><sink_block_id>blks2_selector_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_4</source_block_id><sink_block_id>blks2_selector_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>blocks_multiply_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0_0_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0_0_0_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0_0_0_0_1</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0_0_0_0_2</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0_0_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0_0_0_0_3</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0_0_0_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0_0_0_1</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0_0_0_2</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0_0_0_3</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0_0_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0_0_0_4</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0_0_4</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0_0_1</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0_0_1_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0_0_1_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0_0_1_0_1</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0_1_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0_0_1_0_2</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0_1_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0_0_1_1</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0_1_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0_0_1_2</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0_1_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0_0_1_3</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0_1_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0_0_2</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0_0_3</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0_0_4</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0_4</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0_0_5</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0_5</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0_1</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_1_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0_1_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0_1_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0_1_0_1</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_1_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0_1_0_2</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_1_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0_1_0_3</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_1_0_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0_1_1</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_1_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0_1_2</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_1_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0_1_3</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_1_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0_1_4</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_1_1_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0_2</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0_2_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0_2_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0_2_0_1</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_2_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0_2_0_2</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_2_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0_2_1</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_2_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0_2_2</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_2_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0_2_3</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_2_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0_3</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0_4</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_4</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0_5</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_5</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0_6</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_1_4</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>rational_resampler_xxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>qtgui_freq_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_1</source_block_id><sink_block_id>qtgui_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
